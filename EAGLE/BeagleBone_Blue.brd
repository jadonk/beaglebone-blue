# Repository jadonk/beaglebone-blue (continued)

## EAGLE design EAGLE/BeagleBone_Blue.brd (continued)

Parts:
FUD1, FUD2, FUD3, FUD4, FUD5, FUD6: FIDUCIAL; FIDUCIAL_40MIL
MGT1, MGT2, MGT3, MGT4: MOUNTING_HOLE
R158: 10K; 0402-RES
SIP: OSD3358; BEAGLEBONE_BLUE_OSD3358

Connections:
CGND: MGT1.P$1, MGT2.P$1, MGT3.P$1, MGT4.P$1; also elsewhere on the board
GND: R158.2, SIP.A1 (DGND1), SIP.A18 (DGND2), SIP.E19 (DGND3), SIP.E20 (DGND4), SIP.F8 (DGND5), SIP.F19 (DGND6), SIP.G8 (DGND7), SIP.G9 (DGND8), SIP.G11 (DGND9), SIP.G12 (DGND10), SIP.G19 (DGND11), SIP.H6 (DGND12), SIP.H7 (DGND13), SIP.H8 (DGND14), SIP.H9 (DGND15), SIP.H10 (DGND16), SIP.H12 (DGND17), SIP.H19 (DGND18), SIP.J6 (DGND19), SIP.J7 (DGND20), SIP.J8 (DGND21), SIP.J9 (DGND22), SIP.J10 (DGND23), SIP.J11 (DGND24), SIP.J19 (DGND25), SIP.J20 (DGND26), SIP.K7 (DGND27), SIP.K9 (DGND28), SIP.K10 (DGND29), SIP.K11 (DGND30), SIP.K19 (DGND31), SIP.L10 (DGND32), SIP.L11 (DGND33), SIP.L12 (DGND34), SIP.L13 (DGND35), SIP.L19 (DGND36), SIP.M6 (DGND38), SIP.M7 (DGND39), SIP.M8 (DGND40), SIP.M9 (DGND41), SIP.M10 (DGND42), SIP.M12 (DGND43), SIP.M14 (DGND44), SIP.M19 (DGND45), SIP.N7 (DGND46), SIP.N10 (DGND47), SIP.N11 (DGND48), SIP.N14 (DGND49), SIP.N19 (DGND50), SIP.N20 (DGND51), SIP.P19 (DGND52), SIP.P20 (DGND53), SIP.R19 (DGND54), SIP.R20 (DGND55), SIP.T19 (DGND56), SIP.T20 (DGND57), SIP.U19 (DGND58), SIP.V1 (DGND59), SIP.V18 (DGND60), SIP.V19 (DGND61), SIP.W2 (DGND62), SIP.W3 (DGND63), SIP.W5 (DGND65), SIP.W6 (DGND66), SIP.W7 (DGND67), SIP.W8 (DGND68), SIP.W9 (DGND69), SIP.W10 (DGND70), SIP.W11 (DGND71), SIP.W12 (DGND72), SIP.W13 (DGND73), SIP.W14 (DGND74), SIP.W15 (DGND75), SIP.W16 (DGND76), SIP.W17 (DGND77), SIP.W18 (DGND78), SIP.W19 (DGND79), SIP.W20 (DGND80), SIP.Y7 (DGND82)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; also elsewhere on the board
unnamed: R158.1, SIP.B4 (RTC_KALDO_ENN)
VDD_1V8: SIP.D10 (VDD_1V84), SIP.E9 (VDD_1V83); also elsewhere on the board
VDD_ADC: SIP.D8 (VDDA_ADC); also elsewhere on the board
VDD_RTC: SIP.E14 (VDD_RTC3); also elsewhere on the board
VIN_BAT_0: SIP.Y2 (VIN_BAT_0)
VIN_BAT_1: SIP.Y3 (VIN_BAT_1)

Parts:
ANT1, ANT2: U.FL-R-SMT-1(10); U.FL-R-SMT-1
C47, C49, C50, C51, C52, C56: 0.1uF; 0402-CAP
C48, C58: 10pF; 0402-CAP
C53, C59, C60: 10uF; 0805
C57: 1uF; 0402-CAP
OSC1: NZ2520SB-32.768KHZ-NSA3534C; NZ2520S
R9: 10K, DNP; 0402-RES
R78, R79, R80, R81, R82, R83, R84, R85, R86, R92, R93, R96, R97, R100, R123, R124: 33; 0402-RES
R87, R88: 100K; 0402-RES
R89, R108: 1K, DNP; 0402-RES
R90: 1K; 0402-RES
R98, R99, R101, R102, R103, R105: 10K; 0402-RES
R106: 1.5K; 0402-RES
U2: SN74LV1T126DBVR; BEAGLEBONE_BLUE_SOT23-5
U7: WL1835MODGBMOCT; MOC-100(TI)
U9, U10: TXS0108ERGYR; R-PVQFN-N20(TI)

Connections:
3.3V: C49.2, C51.2, C53.1, C56.1, C59.1, U7.46 (VBAT_IN1), U7.47 (VBAT_IN2), U9.19 (VCCB), U10.19 (VCCB); also elsewhere on the board
32.768KHZ: OSC1.3 (OUT), U7.36 (EXT_32K)
ALT.BUFF.OE: R93.2, R106.2, U2.1 (OE), U9.10 (OE), U10.10 (OE)
ANT1_A: C48.2, U7.32 (RF_ANT1)
ANT1_B: ANT1.SIG, C48.1
ANT2_A: C58.2, U7.18 (RF_ANT2)
ANT2_B: ANT2.SIG, C58.1
BT_AUD_CLK: R124.1, U10.1 (A1)
BT_AUD_FSYNC: R123.1, U10.3 (A2)
BT_AUD_IN: R97.1, U10.5 (A4)
BT_AUD_OUT: R100.1, U10.4 (A3)
BT_EN: U9.18 (B2); also elsewhere on the board
BT_EN_1V8: R88.1, U7.41 (BT_EN), U9.3 (A2)
BT_HCI_CTS: R86.1, U10.8 (A7)
BT_HCI_RTS: R85.1, U10.9 (A8)
BT_HCI_RX: R96.1, U10.6 (A5)
BT_HCI_TX: R92.1, U10.7 (A6)
GND: ANT1.GND1, ANT1.GND2, ANT2.GND1, ANT2.GND2, C47.2, C49.1, C50.2, C51.1, C52.2, C53.2, C56.2, C57.1, C59.2, C60.1, OSC1.2 (GND), R87.2, R88.2, R89.2, R106.1, R108.2, U2.3 (GND), U7.1 (GND1), U7.7 (GND2), U7.9 (GND3), U7.15 (GND4), U7.16 (GND5), U7.17 (GND6), U7.19 (GND7), U7.20 (GND8), U7.23 (GND9), U7.24 (GND10), U7.28 (GND11), U7.29 (GND12), U7.30 (GND13), U7.31 (GND14), U7.33 (GND15), U7.34 (GND16), U7.35 (GND17), U7.37 (GND18), U7.39 (GND19), U7.44 (GND20), U7.45 (GND21), U7.48 (GND22), U7.49 (GND23), U7.54 (GND24), U7.55 (GND25), U7.59 (GND26), U7.61 (GND27), U7.63 (GND28), U7.64 (GND29), U7.G1, U7.G2, U7.G3, U7.G4, U7.G5, U7.G6, U7.G7, U7.G8, U7.G9, U7.G10, U7.G11, U7.G12, U7.G13, U7.G14, U7.G15, U7.G16, U7.G17, U7.G18, U7.G19, U7.G20, U7.G21, U7.G22, U7.G23, U7.G24, U7.G25, U7.G26, U7.G27, U7.G28, U7.G29, U7.G30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; also elsewhere on the board
MCASP0_ACLKR: U10.20 (B1); also elsewhere on the board
MCASP0_AXR0: U10.17 (B3); also elsewhere on the board
MCASP0_AXR1: U10.16 (B4); also elsewhere on the board
MCASP0_FSR: U10.18 (B2); also elsewhere on the board
MMC2_CLK: U9.13 (B7); also elsewhere on the board
MMC2_CMD: U9.12 (B8); also elsewhere on the board
MMC2_DAT0: U9.14 (B6); also elsewhere on the board
MMC2_DAT1: U9.15 (B5); also elsewhere on the board
MMC2_DAT2: U9.16 (B4); also elsewhere on the board
MMC2_DAT3: U9.17 (B3); also elsewhere on the board
unnamed: OSC1.1 (EN), R90.1
unnamed: R100.2, U7.57 (BT_AUD_OUT)
unnamed: R9.2, R84.2, U7.14 (WLAN_IRQ)
unnamed: R83.2, U7.13 (WL_SDIO_D3)
unnamed: R82.2, U7.12 (WL_SDIO_D2)
unnamed: R81.2, U7.11 (WL_SDIO_D1)
unnamed: R80.2, U7.10 (WL_SDIO_D0)
unnamed: R78.2, U7.8 (WL_SDIO_CLK)
unnamed: R79.2, U7.6 (WL_SDIO_CMD)
unnamed: R85.2, U7.50 (BT_HCI_RTS)
unnamed: R86.2, U7.51 (BT_HCI_CTS)
unnamed: R92.2, U7.52 (BT_HCI_TX)
unnamed: R96.2, U7.53 (BT_HCI_RX)
unnamed: R97.2, U7.56 (BT_AUD_IN)
unnamed: R123.2, U7.58 (BT_AUD_FSYNC)
unnamed: R124.2, U7.60 (BT_AUD_CLK)
UART3_CTSN: R89.1, U10.12 (B8); also elsewhere on the board
UART3_RTSN: R108.1, U10.13 (B7); also elsewhere on the board
UART3_RX: U10.14 (B6); also elsewhere on the board
UART3_TX: U10.15 (B5); also elsewhere on the board
VDD_1V8: C47.1, C50.1, C52.1, C57.2, C60.2, OSC1.4 (VCC), R9.1, R90.2, R98.1, R99.1, R101.1, R102.1, R103.1, R105.1, U2.5 (VCC), U7.38 (VIO), U9.2 (VCCA), U10.2 (VCCA); also elsewhere on the board
WLAN_IRQ: U2.4 (Y); also elsewhere on the board
WL_BT_OE: R93.1; also elsewhere on the board
WL_EN: U9.20 (B1); also elsewhere on the board
WL_EN_1V8: R87.1, U7.40 (WLAN_EN), U9.1 (A1)
WL_IRQ: R84.1, U2.2 (A)
WL_SDIO_CLK: R78.1, R103.2, U9.8 (A7)
WL_SDIO_CMD: R79.1, R105.2, U9.9 (A8)
WL_SDIO_D0: R80.1, R98.2, U9.7 (A6)
WL_SDIO_D1: R81.1, R99.2, U9.6 (A5)
WL_SDIO_D2: R82.1, R101.2, U9.5 (A4)
WL_SDIO_D3: R83.1, R102.2, U9.4 (A3)

Notes on the sheet:
DNP if WL1831 is used

Board: 4 copper layers, 86.4 x 54.6 mm, 302 parts (122 on the bottom side), 268 nets.

Other parts of the board:
BOARD: BEAGLEBONE_BLUE_NO_HOLES
U$2: BATTERY_INDICATOR_LEFT
U$5: XYZ_BIG

File BeagleBone_Blue_BOM.csv (part):

"Qty";"Value";"Device";"Package";"Parts";"Description";"DATASHEETURL";"DESCRIPTION";"FAMILY_NAME";"GENERIC_PART_NUMBER";"INDUSTRY_STD_PKG_TYPE";"MANUFACTURER";"MANUFACTURER_PART_NUMBER";"MPN";"OC_FARNELL";"OC_NEWARK";"PACKAGE";"PACKAGE_DESIGNATOR";"PIN_COUNT";"PROD_ID";"SUPPLIER";"TP_SIGNAL_NAME";"VALUE";"VENDOR";
"1";"";"DIODEDO214AA";"DO-214AA";"D9";"Diode";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"3";"";"DIODESOD-123";"SOD-123";"D1, D2, D3";"Diode";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";".1, 0805";"R-US_R0805";"R0805";"R107";"RESISTOR, American symbol";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"3";"0";"RESISTOR0402-RES";"0402-RES";"R111, R149, R150";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"0";"RESISTOR0603";"0603-RES";"R112, R119";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"0, DNP";"RESISTOR0603";"0603-RES";"R121";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"0.1";"RESISTOR0603";"0603-RES";"R4";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"31";"0.1uF";"CAP0402-CAP";"0402-CAP";"C1, C2, C6, C8, C9, C13, C14, C15, C17, C18, C19, C22, C24, C27, C28, C35, C37, C39, C40, C41, C43, C44, C45, C47, C49, C50, C51, C52, C54, C55, C56";"Capacitor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"4";"1.5K";"RESISTOR0402-RES";"0402-RES";"R2, R23, R58, R106";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"17";"100K";"RESISTOR0402-RES";"0402-RES";"R16, R17, R87, R88, R113, R115, R116, R118, R120, R122, R125, R127, R129, R131, R135, R140, R143";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"100k";"RESISTOR0402-RES";"0402-RES";"R47";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"100uF 16V";"CPOL-USD";"PANASONIC_D";"C11";"POLARIZED CAPACITOR, American symbol";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"10118192-0001LF";"10118192-0001LF";"10118192-0001LF(MICRO-USB-B-AMPHENOL-FCI)";"X4";"Amphenol FCI Micro USB Type B Complete Surface Mount (SMT) no guide holes";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"26";"10K";"RESISTOR0402-RES";"0402-RES";"R26, R35, R54, R55, R56, R57, R60, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R94, R98, R99, R101, R102, R103, R105, R158";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"10K, DNP";"RESISTOR0402-RES";"0402-RES";"R9";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"4";"10k";"RESISTOR0402-RES";"0402-RES";"R5, R6, R8, R48";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"6";"10pF";"CAP0402-CAP";"0402-CAP";"C29, C30, C31, C32, C48, C58";"Capacitor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"13";"10uF";"CAP0805";"0805";"C3, C5, C7, C12, C16, C20, C23, C25, C26, C34, C38, C46, C53";"Capacitor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"120";"INDUCTOR/FERRITE-BEAD'0603'";"L0603";"L4, L5";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"120, DNP";"RESISTOR0603";"0603-RES";"R104";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"3";"150";"RESISTOR0402-RES";"0402-RES";"R27, R28, R34";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"8";"1K";"RESISTOR0402-RES";"0402-RES";"R46, R61, R62, R63, R64, R90, R91, R95";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"1K, DNP";"RESISTOR0402-RES";"0402-RES";"R89, R108";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"1M";"RESISTOR0402-RES";"0402-RES";"R18, R20";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"1k";"RESISTOR0402-RES";"0402-RES";"R3, R44";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"1nF";"CAP0402-CAP";"0402-CAP";"C21, C42";"Capacitor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"3";"1uF";"CAP0402-CAP";"0402-CAP";"C4, C10, C57";"Capacitor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"2.2uF";"CAP0402-CAP";"0402-CAP";"C33, C36";"Capacitor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"24 MHz";"CRYSTAL_5X3.2MM";"CRYSTAL_5X3.2MM";"Y1";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"7";"240";"RESISTOR0402-RES";"0402-RES";"R21, R22, R29, R30, R31, R32, R33";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"24LC_32AT-I/OT";"24LC_32AT-I/OT";"SOT95P290X145-5N";"U5";"IC, I2C Serial EEPROM,SOT-23-5";"";"";"";"";"";"";"";"24LC32AT-I/OT";"1700993  ";"08P0113";"SOT-23-5 ";"";"";"";"MICROCHIP";"";"";"";
"1";"3.6 uH";"INDUCTOR";"8X8MM_INDUCTOR";"L3";"Inductors";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"3.3uH";"";
"1";"32.768kHz";"CRYSTAL_3.2X1.5";"CRYSTAL_3.2X1.5";"Y2";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"20";"33";"RESISTOR0402-RES";"0402-RES";"R15, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R92, R93, R96, R97, R100, R123, R124, R156";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"23";"4.7k";"RESISTOR0402-RES";"0402-RES";"R7, R10, R11, R12, R13, R14, R24, R25, R36, R37, R38, R39, R40, R41, R42, R43, R50, R51, R52, R53, R59, R109, R110";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"3";"47k";"RESISTOR0402-RES";"0402-RES";"R1, R19, R45";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"6.8uH";"INDUCTORBOURNS_SRN6045";"SRN6045";"L1, L2";"Inductors";"";"";"";"";"";"";"";"";"";"";"";"";"";"NDUC-11627";"";"";"33uH";"";
"1";"65k";"RESISTOR0402-RES";"0402-RES";"R49";"Resistor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"AOZ1284";"AOZ1284";"SO08-EXPOSED";"6VREG";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"AP1509SOIC-8-TIGHT";"AP1509SOIC-8-TIGHT";"SO08-TIGHT";"5VREG";"150KHz, 2A PWM BUCK DC/DC CONVERTER";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"BATTERY";"JST_XH_3-PIN";"JST_XH_3-PIN";"LIPO";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"7";"BLUE";"LED0603";"LED-0603";"0, 1, 2, 3, BT, ON, WL";"LEDs";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"BMP280";"BMP280";"BMP280";"BMP";"BOSCH BMP280 Digital Pressure Sensor";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"BQ29209";"BQ29209";"8-SON_3X3MM";"BAL";"BQ29209 2-CELL Balance and Overvoltage Protection";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"2";"BSS138W-7-F";"BSS138W-7-F";"SOT-323(DIODES)";"T1, T2";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"EMMC";"EMMC04G-S100-B08U";"MICRON_EMMC_153";"U13";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"6";"FIDUCIAL";"FIDUCIAL";"FIDUCIAL_40MIL";"FUD1, FUD2, FUD3, FUD4, FUD5, FUD6";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"4";"GREEN";"LED0603";"LED-0603";"B1, B2, B3, G";"LEDs";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"GRN";"LED0603";"LED-0603";"CHG";"LEDs";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"3";"H4P-SMD-2.0";"GROVE-CONNECTOR-SMD(4+2P-2.0)";"HW4-SMD-2.0";"GP1, I2C1, UT5";"320110030";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"H4P-SMD-2.0";"";
"8";"JST_SH_4";"JST_SH_4";"JST_SH_4_SMD";"CAN, E1, E2, E3, E4, PWR, UT0, UT1";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"5";"JST_SH_6";"JST_SH_6";"JST_SH_6";"ADC, GP0, GPS, S1.1, S1.2";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"4";"JST_ZH_2";"JST_ZH_2";"JST_ZH_2";"M1, M2, M3, M4";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"JST_ZH_3";"JST_ZH_3";"JST_ZH_3";"DSM2";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"1";"MOSFET-N";"MOSFET-NCHANNEL";"SO08-TIGHT";"Q1";"Common NMOSFET Parts";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
"4";"MOUNTING_HOLE";"MOUNTING_HOLE";"MOUNTING_HOLE";"MGT1, MGT2, MGT3, MGT4";"Chassis Mounting Hole w/GND connection ability";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";"";
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