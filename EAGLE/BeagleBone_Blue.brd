# Repository jadonk/beaglebone-blue (continued)

## EAGLE design EAGLE_Black/BeagleBone_Black_Rev C EAGLE PCB.brd

Board: 2 copper layers, 385 parts (250 on the bottom side), 310 nets.

Parts:
C1, C2, C7, C8, C9, C11, C12, C39, C40, C55, C62, C96, C153: 10uF,_10V; 805_1PRIMARY
C3, C27, C29, C31, C33, C36, C37, C42, C47, C56, C57, C59, C61, C68, C72, C74, C75, C76, C88, C92, C93, C94, C101, C105, C127, C129, C130, C145, C154, C155, C159: 0.1uf,_6V3; 402_2PRIMARY
C4, C10, C13, C14, C15, C77, C95, C118, C122, C126, C133: 10uF,_10V; 805_2PRIMARY
C5: DOCFIELD
C16, C18, C144, C146, C148, C151: 2.2uF,_6V3; 402_2PRIMARY
C17, C125: 2.2uF,_6V3; 402_1PRIMARY
C19, C136: 470pF,_50V; 402_2PRIMARY
C20, C28, C30, C35, C38, C41, C43, C44, C45, C46, C48, C49, C50, C51, C52, C53, C54, C58, C60, C63, C64, C65, C66, C67, C69, C70, C71, C73, C78, C79, C80, C81, C82, C83, C84, C85, C86, C87, C97, C98, C99, C100, C102, C103, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C117, C119, C120, C121, C124, C128, C131, C132, C135, C147, C149, C150, C152, C158: 0.1uf,_6V3; 402_1PRIMARY
C21, C22, C25, C26: 18pF,_50V; 402_1PRIMARY
C24, C134: 1uF,_10V; 402_1PRIMARY
C32: 1nF,_50V; 402_2PRIMARY
C34: 100uF,_6V3; RD205SMD_250D_1PRIMARY
C89, C90, C91, C104: 1uF,_10V; 402_2PRIMARY
C123: 1nF,_50V; 402_1PRIMARY
C137, C138, C139, C140: 15pF,_DNI; 402_1PRIMARY
C141: 0.022uF,10V; 402_1PRIMARY
C142, C143: 30pF,_50V; 402_1PRIMARY
C156, C157, C160, C163, C165, C166, C167, C168, C169, C171, C173: 47pF,_6.3V; 402_2PRIMARY
C161, C162, C164, C170, C172: 47pF,_6.3V; 402_1PRIMARY
D1, D2, D3, D4, D5: 598-8170-107F; LED_0603_1PRIMARY
D6, D7: IP4283CZ10-TT; TSSOP10_1PRIMARY
D8: RB751V40,115; SOD323_1PRIMARY
DUMMY1, DUMMY2, DUMMY3: P:EX40Y40D01
FB1, FB2, FB3, FB4, FB5, FB7: 150OHM800mA; SM-7351-IND-0805_1PRIMARY
FB8: 0.1_Ohm,_0805; SM-7351-IND-0805_1PRIMARY
J1: HEADER_6; SIP6_1PRIMARY
L1, L2, L3: 2.2uH,_2.6A; 2520_1PRIMARY
MTG1, MTG2, MTG3, MTG4: MHOLE; MTGH200C125D_PL_1PRIMARY
P1: PJ-200A; CONN3-PWR-PJ102A_1PRIMARY
P2: CTI_JTAG,DNI; HEADER10X2_SMD_1PRIMARY
P3: USB-A_Conn._-_87520-xx1xx; USB_A_SH_1PRIMARY
P4: mini_USB-B; USB5MINI_4SHIELDED_SMD-5_1PRIMARY
P5: WE_7499010211A; RJ45-7499010211A_1PRIMARY
P6: 10118241-001RLF; CONN19_HDMI_1PRIMARY
P8, P9: FEMALE_HEADER_2x23; HEADER23X2_1PRIMARY
P10: MOLEX_502570-001; SD-MICRO-SCHA5B0300_1PRIMARY
Q1, Q2: DMC56404; SMINI6-F3-B_1PRIMARY
R1, R77, R79, R80, R82, R83, R84, R85, R86, R87, R88, R89, R94, R95, R165: 100K,_1%; 402_2PRIMARY
R3, R4, R119: 1.5K,_1%; 402_2PRIMARY
R5, R6, R7, R8, R19, R27, R50, R149, R162: 0R,_1%; 402_2PRIMARY
R9: 0R,_1%,_DNI; 402_2PRIMARY
R10: 470K,_5%; 402_2PRIMARY
R11: 280K,_1%; 402_1PRIMARY
R12: 820,_5%; 402_1PRIMARY
R14: 10K,_1%; 402_1PRIMARY
R17: 1M,_1%; 402_1PRIMARY
R18, R21, R28, R45, R46, R47, R48, R167: 33,_0402; 402_2PRIMARY
R20, R49, R51, R137, R142, R159, R160, R161: 0R,_1%; 402_1PRIMARY
R22, R120, R121, R122, R123: 49.9,_1%; 402_1PRIMARY
R23, R24, R25: 4.75K,_1%; 402_2PRIMARY
R26, R163, R164: 4.75K,_1%; 402_1PRIMARY
R52, R111, R118, R148, R150, R151, R152, R153, R154, R155, R157: 10k,_1%; 402_2PRIMARY
R53, R54, R96, R98, R100, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R115, R116, R117, R135, R145, R156, R158: 10k,_1%; 402_1PRIMARY
R55, R57, R59, R69: 100K,_1%,_DNI; 402_1PRIMARY
R56, R65, R66, R67, R68, R76, R78: 100K,_1%; 402_1PRIMARY
R58, R60, R61, R62, R63, R64, R70: 100K,_1%,DNI; 402_1PRIMARY
R71, R72, R73, R74: 820,_5%; 402_2PRIMARY
R75: 100; 402_2PRIMARY
R81, R90, R91, R92, R93: 100K,_1%,_DNI; 402_2PRIMARY
R97, R112, R113, R114, R146, R147: 1.5K,_1%; 402_1PRIMARY
R99: 240,_1%; 402_2PRIMARY
R124: 10,_1%,DNI; 402_2PRIMARY
R125, R126, R127, R128, R133, R139: 100,_1%; 402_2PRIMARY
R129, R131, R134, R138: 100,_1%; 402_1PRIMARY
R130, R132: 470,_5%; 402_1PRIMARY
R136: 0.1,_0805; 805_2PRIMARY
R140: 0R,_1%,DNI; 402_1PRIMARY
R141: 1M,_1%,DNI; 402_2PRIMARY
R143: 10,_1%; 402_2PRIMARY
R144: 12.1K,_1%; 402_1PRIMARY
R166: 27K,_1%; 402_2PRIMARY
RT1: PTC_RXEF010; POLYSW200-5638-310_1PRIMARY
S1, S2, S3: KMR231GLFS; SW4SMD_63X161LS_1PRIMARY
TP1, TP4: TESTPT1; TP1-8040_1PRIMARY
TP2, TP3: TESTPT1; TP60C_SMD_1PRIMARY
TP5, TP6, TP7, TP8: TESTPT1; TP60C33D_1PRIMARY
U2: TPS65217C; U_48_RSL_1PRIMARY
U3: SN74LVC1G06DCK; DCK5_2P15X1P4_1PRIMARY
U4: TL5209; SO8-25X75_1PRIMARY
U5: IC_AM335X_ZCE_1; AM33XX_15X15_1PRIMARY
U6: SN74LVC1G74DCTR; SOP8_DCT_1PRIMARY
U7: 24LC32A; SOT23-5_1PRIMARY
U8: TPS2051__DGN_; DGN-16X60_1PRIMARY
U9, U10: TPD4S012; U_6_DRY_1PRIMARY
U11: TDA19988; QFN64S9X9P5_1PRIMARY
U12: MT41K256M16HA_-125:E; BGA96_T9_P8_9X14_1PRIMARY
U13: eMMC,_2GB; BGA153_P14_P5_11P5X13_1PRIMARY
U14: LAN8710A; QFN32_5X5MM_EP3P3MM_1PRIMARY
U15: SN74LVC2G241; U_8_DCU_1PRIMARY
Y1: 32.768kHz; XTAL4_126-216SMD_1PRIMARY
Y2: 24MHz; XTAL150SMD_125X196_1PRIMARY
Y3: 25.000MHz; XTAL150SMD_125X196_1PRIMARY
Y4: 24.576MHz; OSC4_61X65LS_79X98SMD_1PRIMARY

Connections:
12MHZ: R21.2, U11.27
12M_LOOP: U6.2, U6.3
AIN0: P9.39, U5.24
AIN1: P9.40, U5.43
AIN2: P9.37, U5.25
AIN3: P9.38, U5.7
AIN4: P9.33, U5.44
AIN5: P9.36, U5.26
AIN6: P9.35, U5.8
AIN7: R163.2, R164.1, U5.45
B_UART0_RX: J1.4, R165.1, U15.2
B_UART0_TX: J1.5, U15.3
CAP_VBB_MPU: C91.1, U5.46
CAP_VDD_SRAM_CORE: C89.1, U5.63
CAP_VDD_SRAM_MPU: C90.1, U5.65
CLKOUT2: P2.18, P9.41, R19.2, R20.1
CLKOUT_SRC: R19.1, U5.68
CRS: R139.2, U14.14
DDR_A0: U5.93, U12.75
DDR_A1: U5.127, U12.82
DDR_A2: U5.76, U12.81
DDR_A3: U5.39, U12.74
DDR_A4: U5.38, U12.83
DDR_A5: U5.19, U12.80
DDR_A6: U5.59, U12.89
DDR_A7: U5.74, U12.86
DDR_A8: U5.58, U12.95
DDR_A9: U5.37, U12.87
DDR_A10: U5.94, U12.64
DDR_A11: U5.92, U12.88
DDR_A12: U5.75, U12.76
DDR_A13: U5.129, U12.93
DDR_A14: U5.130, U12.94
DDR_A15: U5.57, U12.70
DDR_BA0: U5.40, U12.68
DDR_BA1: U5.73, U12.77
DDR_BA2: U5.21, U12.69
DDR_CASN: U5.91, U12.57
DDR_CKE: R96.2, U5.111, U12.60
DDR_CLK: U5.56, U12.52
DDR_CLKN: U5.55, U12.58
DDR_CSN: U5.128, U12.62
DDR_D0: U5.201, U12.27
DDR_D1: U5.202, U12.34
DDR_D2: U5.217, U12.32
DDR_D3: U5.218, U12.35
DDR_D4: U5.219, U12.45
DDR_D5: U5.220, U12.47
DDR_D6: U5.237, U12.38
DDR_D7: U5.238, U12.46
DDR_D8: U5.145, U12.22
DDR_D9: U5.163, U12.15
DDR_D10: U5.164, U12.17
DDR_D11: U5.165, U12.14
DDR_D12: U5.166, U12.4
DDR_D13: U5.183, U12.2
DDR_D14: U5.184, U12.11
DDR_D15: U5.199, U12.3
DDR_DQM0: U5.200, U12.28
DDR_DQM1: U5.146, U12.21
DDR_DQS0: U5.235, U12.33
DDR_DQS1: U5.181, U12.16
DDR_DQSN0: U5.236, U12.39
DDR_DQSN1: U5.182, U12.10
DDR_ODT: U5.109, U12.55
DDR_RASN: U5.112, U12.51
DDR_RESETN: R97.2, U5.110, U12.92
DDR_VREF: C28.1, C123.1, C124.1, R98.2, R100.1, U5.148, U12.43, U12.71
DDR_VTP: R22.2, U5.147
DDR_WEN: U5.20, U12.63
DGND: C1.1, C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C24.2, C27.2, C28.2, C29.2, C30.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.1, C40.1, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.1, C56.1, C57.1, C58.2, C59.2, C60.1, C61.1, C62.1, C63.2, C64.2, C65.2, C66.2, C67.2, C68.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2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
DVI_+5V: P6.19, R146.1, R147.1, RT1.2
EHRPWM1A: P9.14, U5.302
EHRPWM1B: P9.16, U5.284
EHRPWM2A: P8.19, U5.298
EHRPWM2B: P8.13, U5.280
EMMC_RSTN: R111.2, R162.2, U13.97
EMMC_VCCI: C125.1, U13.30
ENZ_KALDO_1P8V: R54.2, U5.22
ETH_TXD4: R145.1, U14.18
GNDA_ADC: C31.2, C32.2, C33.2, C93.2, FB3.1, P9.34, U5.9, U5.80
GND_EARTH: MTG1.1, MTG2.1, MTG3.1, MTG4.1, P3.5, P3.6, P4.6, P4.7, P4.8, P4.9, P5.14, P5.15, P6.20, P6.21, P6.22, P6.23, P10.11, P10.12, P10.13, P10.14, P10.15, P10.16, R136.2
GND_OSC0: C25.2, C26.2, U5.317
GND_OSC1: C21.1, C22.1, U5.5
GPIO0_7: P9.42, R50.1, R51.1
GPIO0_7SRC: R50.2, U5.54
GPIO0_26: P8.14, U5.281
GPIO0_27: P8.17, U5.300
GPIO1_12: P8.12, U5.282
GPIO1_13: P8.11, U5.264
GPIO1_14: P8.16, U5.319
GPIO1_15: P8.15, U5.301
GPIO1_16: P9.15, R160.2, R161.2
GPIO1_17: P9.23, U5.320
GPIO1_28: P9.12, U5.306
GPIO1_29: P8.26, U5.312
GPIO2_1: P8.18, U5.318
GPIO3_18: R51.2, U5.30
GPIO3_19: P9.27, U5.49
GPIO3_20: R20.2, U5.67
GPIO3_21: P9.25, R167.2, U5.14
GRNA: P5.10, U14.3
GRN_C: P5.11, R132.2
HDMICLK_DISN: U5.323, Y4.1
HDMI_1V8: C144.1, C145.1, C146.1, C147.1, C148.1, C149.1, C150.1, C151.1, FB5.1, U11.5, U11.14, U11.29, U11.35, U11.36, U11.41, U11.46, U11.47, U11.48, U11.55
HDMI_CEC: D8.1, P6.15, U11.30
HDMI_CEC_D: D8.2, R166.1
HDMI_DSCL: P6.17, R146.2, U11.33
HDMI_DSDA: P6.18, R147.2, U11.32
HDMI_HPD: P6.1, U11.31
HDMI_INT: R158.2, U5.304, U11.50
HDMI_SWING: R148.1, U11.34
HDMI_TX0+: D6.2, P6.9, U11.40
HDMI_TX0-: D6.1, P6.11, U11.39
HDMI_TX1+: D7.5, P6.6, U11.43
HDMI_TX1-: D7.4, P6.8, U11.42
HDMI_TX2+: D7.2, P6.3, U11.45
HDMI_TX2-: D7.1, P6.5, U11.44
HDMI_TXC+: D6.4, P6.12, U11.38
HDMI_TXC-: D6.5, P6.14, U11.37
I2C0_SCL: R3.2, U2.28, U5.52, U7.1, U11.52
I2C0_SDA: R4.2, U2.27, U5.53, U7.3, U11.51
I2C1_SCL: P9.17, U5.16
I2C1_SDA: P9.18, U5.34
I2C2_SCL: P9.19, U5.71
I2C2_SDA: P9.20, U5.72
JTAG_EMU0: P2.13, R23.2, U5.50
JTAG_EMU1: P2.14, R24.2, U5.32
JTAG_TCK: P2.9, P2.11, U5.12
JTAG_TDI: P2.3, U5.29
JTAG_TDO: P2.7, U5.11
JTAG_TMS: P2.1, U5.47
JTAG_TRSTN: P2.2, R25.1, U5.28
LCDDE: R48.1, U5.258
LCDPCLK: R45.1, U5.311
LCDVHYNC: R47.1, U5.257
LCDVSYNC: R46.1, U5.293
LCD_DATA0: C173.1, P8.45, R70.2, R95.1, U5.253, U11.15
LCD_DATA1: C171.1, P8.46, R69.2, R94.1, U5.254, U11.13
LCD_DATA2: C172.1, P8.43, R68.2, R75.1, R93.1, U5.255, U11.12
LCD_DATA3: C170.1, P8.44, R67.2, R92.1, U5.256, U11.11
LCD_DATA4: C169.1, P8.41, R66.2, R91.1, U5.271, U11.10
LCD_DATA5: C163.1, P8.42, R65.2, R90.1, U5.272, U11.7
LCD_DATA6: C162.1, P8.39, R64.2, R89.1, U5.273, U11.6
LCD_DATA7: C161.1, P8.40, R63.2, R88.1, U5.274, U11.3
LCD_DATA8: C160.1, P8.37, R62.2, R87.1, U5.289, U11.2
LCD_DATA9: C157.1, P8.38, R61.2, R86.1, U5.290, U11.1
LCD_DATA10: C156.1, P8.36, R60.2, R85.1, U5.291, U11.64
LCD_DATA11: C168.1, P8.34, R59.2, R84.1, U5.292, U11.60
LCD_DATA12: C167.1, P8.35, R58.2, R83.1, U5.308, U11.59
LCD_DATA13: C166.1, P8.33, R57.2, R82.1, U5.309, U11.58
LCD_DATA14: C165.1, P8.31, R56.2, R81.1, U5.310, U11.57
LCD_DATA15: C164.1, P8.32, R55.2, R80.1, U5.275, U11.56
LCD_DE: P8.30, R48.2, U11.20
LCD_HSYNC: P8.29, R47.2, U11.22
LCD_PCLK: P8.28, R45.2, U11.4
LCD_VSYNC: P8.27, R46.2, U11.21
LDO_PGOOD: U2.46, U5.23
LEDAA: D2.2, R72.2
LEDAC: D2.1, Q1.6
LEDBA: D3.2, R73.2
LEDBC: D3.1, Q1.3
LEDCA: D4.2, R74.2
LEDCC: D4.1, Q2.6
LEDDA: D5.2, R71.2
LEDDC: D5.1, Q2.3
MDIO_CLK: U5.216, U14.17
MDIO_DATA: R119.2, U5.215, U14.16
MII1_COL: R138.1, U5.142
MII1_CRS_DV: R139.1, U5.143
MII1_REFCLK: R28.2, R124.1, R140.1
MII1_RXCLK: R131.1, U5.198
MII1_RXD0: R128.1, U5.214
MII1_RXD1: R127.1, U5.195
MII1_RXD2: R126.1, U5.196
MII1_RXD3: R125.1, U5.197
MII1_RXDV: R129.1, U5.161
MII1_RXERR: R133.1, U5.159
MII1_TXCLK: R134.1, U5.180
MII1_TXD0: U5.179, U14.22
MII1_TXD1: U5.178, U14.23
MII1_TXD2: U5.177, U14.24
MII1_TXD3: U5.162, U14.25
MII1_TXEN: U5.160, U14.21
MMC0_CD: P2.19, P10.10, R157.1, U5.51
MMC0_CLKO: P10.5, R152.2, U5.125
MMC0_CMD: P10.3, R151.2, U5.126
MMC0_DAT0: P10.7, R153.2, U5.124
MMC0_DAT1: P10.8, R154.2, U5.123
MMC0_DAT2: P10.1, R150.2, U5.108
MMC0_DAT3: P10.2, R155.2, U5.107
MMC1_CLK: P8.21, R110.2, U5.297, U13.117
MMC1_CMD: P8.20, R109.2, U5.315, U13.116
MMC1_DAT0: P8.25, R101.2, U5.295, U13.3
MMC1_DAT1: P8.24, R102.2, U5.313, U13.4
MMC1_DAT2: P8.5, R103.2, U5.260, U13.5
MMC1_DAT3: P8.6, R104.2, U5.278, U13.16
MMC1_DAT4: P8.23, R105.2, U5.296, U13.17
MMC1_DAT5: P8.22, R106.2, U5.314, U13.18
MMC1_DAT6: P8.3, R107.2, U5.261, U13.19
MMC1_DAT7: P8.4, R108.2, U5.279, U13.20
MODE2: R113.1, R138.2, U14.15
NETC19_1: C19.1, R10.1, R11.2, U4.4
NETR21_1: R21.1, U6.5
NETR75_2: R75.2, S2.1, S2.3
NETR149_1: R149.1, U11.49
NETR159_2: R159.2, U5.249
NETR162_1: R162.1, U3.4
NETR167_1: R167.1, Y4.3
NETTP5_1: TP5.1, U2.4, U2.5
NETTP6_1: TP6.1, U2.6
NETTP7_1: TP7.1, U2.11
NETU3_2: U3.2, U5.266
OSC0_IN: C25.1, R17.1, U5.316, Y2.2
OSC0_OUT: C26.1, R17.2, U5.299, Y2.1
OSC1_IN: C21.2, U5.6, Y1.1
OSC1_OUT: C22.2, U5.4, Y1.4
PHYX: C142.1, R143.2, Y3.2
PHY_VDDCR: C134.1, C136.1, U14.6
PHY_XTAL1: C143.1, R141.2, R142.1, Y3.1
PHY_XTAL2: R141.1, R143.1, U14.4
PMIC_INT: R1.2, U2.45, U5.36
PMIC_PGOOD: U2.26, U5.33
PMIC_POWR_EN: U2.9, U5.42
PROC_A15: R18.1, U5.15
PWR_BUT: P9.9, S3.2, S3.4, U2.25
PWR_LEDR: D1.1, R12.2
P_BYPASS: C4.2, U2.47
P_INT_LDO: C3.2, U2.48
P_L1: L1.1, U2.20
P_L2: L2.1, U2.23
P_L3: L3.1, U2.31
RBIAS: R144.1, U14.32
RCLKIN: R140.2, R142.2, U14.5
REFCLKO: R118.1, R124.2, R131.2, U14.7
RXD0_MODE0: R112.1, R128.2, U14.11
RXD1_MODE1: R114.1, R127.2, U14.10
RXD2_RMIISEL: R117.1, R126.2, U14.9
RXD3_PHYAD2: R116.1, R125.2, U14.8
RXDV: R129.2, U14.26
RXER_PHYAD0: R115.1, R133.2, U14.13
RXN: C138.1, P5.3, R121.1, U14.30
RXP: C137.1, P5.2, R120.1, U14.31
SPI1_CS0: P9.28, U5.48, U11.25
SPI1_D0: P9.29, U5.31, U11.24
SPI1_D1: P9.30, U5.66
SPI1_SCLK: P9.31, U5.13, U11.23
SYS_5V: C7.2, C8.2, C10.2, C13.2, C17.1, C34.1, P9.7, P9.8, R71.1, R72.1, R73.1, R74.1, RT1.1, U2.2, U2.7, U2.8, U2.21, U2.22, U2.32, U2.39, U2.42, U4.2, U8.2, U8.3
SYS_RESETN: C24.1, C30.1, P2.15, P9.10, R14.2, S1.2, S1.4, U5.10, U14.19
TCT_RCT: C141.1, P5.5, P5.6, R137.1
TESTOUT: TP3.1, U5.3
TIMER4: P8.7, U5.259
TIMER5: P8.9, U5.276
TIMER6: P8.10, U5.294
TIMER7: P8.8, U5.277
TXCLK: R134.2, U14.20
TXN: C140.1, P5.7, R123.1, U14.28
TXP: C139.1, P5.4, R122.1, U14.29
U5_H18: R28.1, U5.144
U5_R13: R160.1, U5.265
U5_T13: R161.1, U5.283
UART0_RX: U5.87, U15.6
UART0_TX: U5.88, U15.5
UART1_RXD: P9.26, U5.70
UART1_TXD: P9.24, U5.69
UART2_RXD: P9.22, U5.17
UART2_TXD: P9.21, U5.35
UART4_RXD: P9.11, U5.287
UART4_TXD: P9.13, U5.305
USB0_DM: P4.2, U5.234, U10.2
USB0_DP: P4.3, U5.233, U10.1
USB0_ID: P4.4, U5.250, U10.3
USB1_DM: P3.2, U5.270, U9.2
USB1_DP: P3.3, U5.269, U9.1
USB1_DRVVBUS: R53.1, U5.105, U8.4
USB1_ID: R49.2, U5.251
USB1_OCN: R52.2, U5.286, U8.5
USB1_PWR: C35.1, FB7.1, FB8.2, U8.6, U8.7, U8.8, U9.6
USB1_VBUS: FB8.1, U5.288
USB_DC: C1.2, C36.1, P4.1, R159.1, U2.12, U10.6
USR0: Q1.2, R76.1, U5.321
USR1: Q1.5, R77.1, U5.303
USR2: Q2.2, R78.1, U5.285
USR3: Q2.5, R79.1, U5.322
VBUS: FB7.2, P3.1
VDCDC1: L1.2, R6.1, U2.19
VDDS: C80.1, C81.1, C82.1, C83.1, C84.1, C85.1, R8.2, R9.1, U5.78, U5.86, U5.99, U5.175, U5.222, U5.243, U5.248
VDDS_DDR: C9.2, C95.2, C96.2, C97.1, C98.1, C99.1, C100.1, C101.1, C102.1, C103.1, C107.1, C108.1, C109.1, C110.1, C111.1, C112.1, C113.1, C114.1, C115.1, C116.1, C117.1, C118.2, C119.1, C120.1, C121.1, C122.2, R6.2, R97.1, R98.1, U5.77, U5.95, U5.113, U5.131, U5.149, U5.167, U5.185, U12.1, U12.5, U12.8, U12.13, U12.18, U12.20, U12.24, U12.30, U12.31, U12.40, U12.44, U12.48, U12.56, U12.59, U12.73, U12.78, U12.85, U12.90
VDD_1V8: C14.2, C78.1, C86.1, C88.1, FB1.1, FB2.2, FB5.2, R9.2, U2.40, U5.64, U5.81, U5.232, U5.268
VDD_3V3A: C15.2, C27.1, C37.1, C38.1, C56.2, C57.2, C58.1, C59.1, C60.2, C61.2, C66.1, C67.1, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.1, C87.1, C152.1, C158.1, C159.1, R1.1, R3.1, R4.1, R14.1, R52.1, R55.1, R56.1, R57.1, R58.1, R59.1, R60.1, R61.1, R62.1, R63.1, R64.1, R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R156.1, U2.43, U3.5, U5.82, U5.83, U5.84, U5.85, U5.104, U5.122, U5.140, U5.158, U5.176, U5.194, U5.221, U5.231, U5.239, U5.240, U5.241, U5.242, U5.244, U5.245, U5.246, U5.247, U5.267, U6.6, U6.7, U6.8, U7.4, Y4.4
VDD_3V3AUX: C18.1, D1.2, U2.1, U4.1
VDD_3V3B: C20.1, C29.1, C126.2, C127.1, C128.1, C129.1, C130.1, C135.1, C153.1, C154.1, C155.2, FB4.1, P2.5, P9.3, P9.4, P10.4, R11.1, R23.1, R24.1, R101.1, R102.1, R103.1, R104.1, R105.1, R106.1, R107.1, R108.1, R109.1, R110.1, R111.1, R112.2, R113.2, R114.2, R119.1, R150.1, R151.1, R152.1, R153.1, R154.1, R155.1, R157.2, R158.1, R163.1, R166.2, U4.3, U13.34, U13.54, U13.65, U13.90, U13.101, U13.115, U13.129, U13.142, U13.144, U14.12, U15.7, U15.8
VDD_5V: C2.2, P1.1, P9.5, P9.6, U2.10
VDD_ADC: C93.1, FB2.1, P9.32, R27.1, U5.62
VDD_CORE: C11.2, C39.2, C40.2, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.2, L3.2, U2.29, U5.96, U5.97, U5.114, U5.115, U5.118, U5.137, U5.156, U5.168, U5.170, U5.174, U5.186, U5.187, U5.188, U5.189, U5.209, U5.211, U5.224, U5.225, U5.228, U5.229
VDD_MPU: C12.2, C62.2, C63.1, C64.1, C65.1, L2.2, U2.24, U5.100, U5.101, U5.102, U5.103, U5.121, U5.139, U5.157
VDD_MPUON: TP2.1, U5.2
VDD_PHYA: C131.1, C132.1, C133.2, FB4.2, R120.2, R121.2, R122.2, R123.2, R137.2, U14.1, U14.27
VDD_PLL: C79.1, C92.1, C94.1, C106.1, FB1.2, U5.79, U5.141, U5.262, U5.263
VDD_RTC: C104.1, U5.60
VIO: R7.2, U2.18
VLDO1: R5.1, R7.1, R8.1, U2.3
VREFP_ADC: C31.1, C32.1, C33.1, R27.2, U5.27
VRTC: C16.1, C105.1, R5.2, R26.1, U5.61
WAKEUP: R26.2, U2.13, U5.41
WP: R156.2, TP4.1, U7.5
XDMA_EVENT_INTR0: P2.17, R18.2, U6.1
YELA: P5.13, R135.1, U14.2
YEL_C: P5.12, R130.2
ZQ: R99.2, U12.65

File BeagleBone_Blue BOM by Parts.xlsx:

Partlist for Project:
Customer:
File: c:/users/james/documents/github/beaglebone-blue/beaglebone_blue.brd.bom
Prepared by: Group #____ SFU Engineering Science, ENSC 204 11/10/2015 11:52 PM
Item | Qty | Part Number | Description | Package | Manufacturer | Suggested Suppliers | Sub/Comments | Part ID.
1 | 93 | 0.1uf,_6V3 |  | 402_1PRIMARY |  |  |  | C20,C28,C30,C35,C38,C41,C43,C44,C45,C46,C48,C49,C50,C51,C52,C53,C54,C58,C60,C63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
2 | 14 | 0R,_1% |  | 402_1PRIMARY |  |  |  | R20,R49,R51,R159,R160,R161,R5,R6,R7,R8,R19,R27,R50,R162
3 | 4 | 1.5K,_1% |  | 402_1PRIMARY |  |  |  | R97,R112,R3,R4
4 | 1 | 1M,_1% |  | 402_1PRIMARY |  |  |  | R17
5 | 2 | 1nF,_50V |  | 402_1PRIMARY |  |  |  | C123,C32
6 | 5 | 1uF,_10V |  | 402_1PRIMARY |  |  |  | C24,C89,C90,C91,C104
7 | 4 | 2.2uF,_6V3 |  | 402_1PRIMARY |  |  |  | C17,C125,C16,C18
8 | 6 | 4.75K,_1% |  | 402_1PRIMARY |  |  |  | R26,R163,R164,R23,R24,R25
9 | 1 | 10K,_1% |  | 402_1PRIMARY |  |  |  | R14
10 | 25 | 10k,_1% |  | 402_1PRIMARY |  |  |  | R53,R54,R96,R98,R100,R101,R102,R103,R104,R105,R106,R107,R108,R109,R110,R156,R52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
11 | 4 | 18pF,_50V |  | 402_1PRIMARY |  |  |  | C21,C22,C25,C26
12 | 1 | 49.9,_1% |  | 402_1PRIMARY |  |  |  | R22
13 | 22 | 100K,_1% |  | 402_1PRIMARY |  |  |  | R56,R65,R66,R67,R68,R76,R78,R1,R77,R79,R80,R82,R83,R84,R85,R86,R87,R88,R89,R94,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
14 | 7 | 100K,_1%,DNI |  | 402_1PRIMARY |  |  |  | R58,R60,R61,R62,R63,R64,R70
15 | 9 | 100K,_1%,_DNI |  | 402_1PRIMARY |  |  |  | R55,R57,R59,R69,R81,R90,R91,R92,R93
16 | 1 | 280K,_1% |  | 402_1PRIMARY |  |  |  | R11
17 | 5 | 820,_5% |  | 402_1PRIMARY |  |  |  | R12,R71,R72,R73,R74
18 | 1 | 0R,_1%,_DNI |  | 402_2PRIMARY |  |  |  | R9
19 | 8 | 33,_0402 |  | 402_2PRIMARY |  |  |  | R18,R21,R28,R45,R46,R47,R48,R167
20 | 1 | 100 |  | 402_2PRIMARY |  |  |  | R75
21 | 1 | 240,_1% |  | 402_2PRIMARY |  |  |  | R99
22 | 1 | 470K,_5% |  | 402_2PRIMARY |  |  |  | R10
23 | 1 | 470pF,_50V |  | 402_2PRIMARY |  |  |  | C19
24 | 23 | 10uF,_10V |  | 805_1PRIMARY |  |  |  | C1,C2,C7,C8,C9,C11,C12,C39,C40,C55,C62,C96,C153,C4,C10,C13,C14,C15,C77,C95,C118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
25 | 3 | 2.2uH,_2.6A |  | 2520_1PRIMARY |  |  |  | L1,L2,L3
26 | 1 | IC_AM335X_ZCE_1 |  | AM33XX_15X15_1PRIMARY |  |  |  | U5
27 | 1 | MT41K256M16HA_-125:E |  | BGA96_T9_P8_9X14_1PRIMARY |  |  |  | U12
28 | 1 | eMMC,_2GB |  | BGA153_P14_P5_11P5X13_1PRIMARY |  |  |  | U13
29 | 1 | SN74LVC1G06DCK |  | DCK5_2P15X1P4_1PRIMARY |  |  |  | U3
30 | 1 | TPS2051__DGN_ |  | DGN-16X60_1PRIMARY |  |  |  | U8
31 | 1 | CTI_JTAG,DNI |  | HEADER10X2_SMD_1PRIMARY |  |  |  | P2
32 | 5 | 598-8170-107F |  | LED_0603_1PRIMARY |  |  |  | D1,D2,D3,D4,D5
33 | 4 | MHOLE |  | MTGH200C125D_PL_1PRIMARY |  |  |  | MTG1,MTG2,MTG3,MTG4
34 | 1 | 24.576MHz |  | OSC4_61X65LS_79X98SMD_1PRIMARY |  |  |  | Y4
35 | 3 |  |  | P:EX40Y40D01 |  |  |  | DUMMY1,DUMMY2,DUMMY3
36 | 1 | 100uF,_6V3 |  | RD205SMD_250D_1PRIMARY |  |  |  | C34
37 | 1 | HEADER_6 |  | SIP6_1PRIMARY |  |  |  | J1
38 | 1 | 0.1_Ohm,_0805 |  | SM-7351-IND-0805_1PRIMARY |  |  |  | FB8
39 | 6 | 150OHM800mA |  | SM-7351-IND-0805_1PRIMARY |  |  |  | FB1,FB2,FB3,FB4,FB5,FB7
40 | 1 | TL5209 |  | SO8-25X75_1PRIMARY |  |  |  | U4
41 | 1 | SN74LVC1G74DCTR |  | SOP8_DCT_1PRIMARY |  |  |  | U6
42 | 1 | 24LC32A |  | SOT23-5_1PRIMARY |  |  |  | U7
43 | 3 | KMR231GLFS |  | SW4SMD_63X161LS_1PRIMARY |  |  |  | S1,S2,S3
44 | 4 | TESTPT1 |  | TP1-8040_1PRIMARY |  |  |  | TP1,TP4,TP2,TP3
45 | 1 | mini_USB-B |  | USB5MINI_4SHIELDED_SMD-5_1PRIMARY |  |  |  | P4
46 | 1 | USB-A_Conn._-_87520-xx1xx |  | USB_A_SH_1PRIMARY |  |  |  | P3
47 | 2 | TPD4S012 |  | U_6_DRY_1PRIMARY |  |  |  | U9,U10
48 | 1 | SN74LVC2G241 |  | U_8_DCU_1PRIMARY |  |  |  | U15
49 | 1 | 32.768kHz |  | XTAL4_126-216SMD_1PRIMARY |  |  |  | Y1
50 | 1 | 24MHz |  | XTAL150SMD_125X196_1PRIMARY |  |  |  | Y2

## EAGLE design BeagleBone Blue SIP Eagle/BeagleBone_Blue.brd

Parts:
5VREG: AP1509SOIC-8-TIGHT; SO08-TIGHT
6V_REG: AOZ1284; SO08-EXPOSED
ADC: JST_SH_6
BAL: BQ29209; 8-SON_3X3MM
BMP: BMP180
C1, C2, C6, C8, C9, C13, C14, C15, C17, C18, C19, C22, C24: 0.1uF; 0402-CAP
C3, C5, C7, C12, C16, C20, C23, C25, C26: 10uF 25V; 0805
C4, C10: 1uF; 0402-CAP
C11: 100uF 16V; PANASONIC_D
C21: 2.2nF 50V; 0402-CAP
CHG: GRN; LED-0603
CHGIC: MP2615
D1, D2, D3: DIODESOD-123; SOD-123
D4: RED; LED-0603
D5, D6, D7: GREEN; LED-0603
D9: DIODEDO214AA; DO-214AA
DSM2: JST_ZH_3SMD_TOP; JST_ZH_3_SMD_TOP
E1, E2, E3, E4: JST_SH_4; JST_SH_4_SMD
GPS: JST_SH_6
GRN: GRN; LED-0603
H1, H2: TB6621FNG; SSOP24
I2C1: JST_SH_4; JST_SH_4_SMD
IMU: MPU-9250; QFN24G-0.4-3X3MM
JACK: 5.5x2.1mm; DCJ0303
L1, L2: 6.8uH; SRN6045
L3: 3.6; 8X8MM_INDUCTOR
LIPO: JST_XH_3-PIN
M1, M2, M3, M4: JST_ZH_2
MODE: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
PAUSE: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
POWER: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
PROT: S-8261; SOT-236
PWR: JST_SH_4; JST_SH_4_SMD
Q3: MOSFET-N; SO08-TIGHT
R1, R19, R45: 47k; 0402-RES
R3, R44: 1k; 0402-RES
R4: 0.1; 0603-RES
R5, R6, R8, R48: 10k; 0402-RES
R7, R10, R11, R12, R13, R14, R25, R36, R37, R38, R39, R40, R41, R42, R43, R50, R51, R52, R53, R54, R55, R56, R57: 4.7k; 0402-RES
R9, R15, R16, R17, R18, R20, R26, R35, R46: 1K; 0402-RES
R21, R22, R29, R30, R31, R32, R33: 261; 0402-RES
R27, R28, R34: 160; 0402-RES
R47: 100k; 0402-RES
R49: 65k; 0402-RES
RED: RED; LED-0603
RESET: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
SPI1.1, SPI1.2: JST_SH_6
U$1: SERVO_HEADERS_8X; 3X8_0.1"_HEADER
UART0, UART1, UART5: JST_SH_4; JST_SH_4_SMD

Connections:
3.3V: BMP.2 (VDD), BMP.3 (VDDIO), C2.2, C8.1, C9.2, C13.1, C16.1, DSM2.1, E1.2, E2.2, E3.2, E4.2, H1.20 (VCC), H2.20 (VCC), I2C1.2, IMU.1 (RESV), IMU.8 (VDDIO), IMU.13 (VDD), IMU.22 (NCS), PWR.3, R9.2, R10.1, R11.2, R12.2, R13.1, R15.2, R16.2, R17.2, R18.2, R20.2, R26.2, R35.2, SPI1.1.2, SPI1.2.2, UART0.2, UART1.2, UART5.2
5.0V: 5VREG.3 (FB), C5.1, GPS.5, L1.2, PWR.4; also elsewhere on the board
AIN0: ADC.3; also elsewhere on the board
AIN1: ADC.4; also elsewhere on the board
AIN2: ADC.5; also elsewhere on the board
AIN3: ADC.6; also elsewhere on the board
BATT_MID: LIPO.P$2 (2), R27.1, R30.1, R44.1
BATT_MINUS: BAL.5 (GND), BAL.6 (CB_EN), C1.2, C15.1, C18.1, C19.2, LIPO.P$3 (3), PROT.2 (VM), PROT.6 (VSS), Q3.1 (S), Q3.2 (S), Q3.3 (S)
CHG_EN: CHGIC.6 (EN), R7.2, R8.1
CO: BAL.8 (OUT), R7.1
DO: PROT.1 (DO), Q3.4 (G)
GND: 5VREG.4 (SD), 5VREG.5 (GND), 5VREG.6 (GND1), 5VREG.7 (GND2), 5VREG.8 (GND3), 6V_REG.3 (GND), ADC.1, BMP.7 (GND), C2.1, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.-, C12.2, C13.2, C16.2, C20.1, C21.1, C23.1, C24.1, C25.2, C26.2, CHGIC.8 (AGND), CHGIC.16 (PGND), D1.A, D9.A, DSM2.2, E1.1, E2.1, E3.1, E4.1, GPS.2, GPS.6, H1.3 (PGND1), H1.4 (PGND1), H1.9 (PGND2), H1.10 (PGND2), H1.18 (GND), H2.3 (PGND1), H2.4 (PGND1), H2.9 (PGND2), H2.10 (PGND2), H2.18 (GND), I2C1.1, IMU.9 (AD0/SDO), IMU.18 (GND), IMU.20 (RESV), IMU.25 (PAD), JACK.2, JACK.3, MODE.1, PAUSE.1, POWER.1, PWR.1, PWR.2, Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), R6.1, R8.2, R14.2, R21.2, R22.2, R25.2, R29.2, R31.2, R32.2, R33.2, R46.1, R47.1, R48.1, R50.2, R51.2, R52.2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; also elsewhere on the board
I2C1_SCL: I2C1.3, R12.1; also elsewhere on the board
I2C1_SDA: I2C1.4, R13.2; also elsewhere on the board
I2C2_SCL: BMP.5 (SCL), IMU.23 (SCL/SCLK), R11.1; also elsewhere on the board
I2C2_SDA: BMP.6 (SDA), IMU.24 (SDA/SDI), R10.2; also elsewhere on the board
IMU_INT: IMU.12 (INT); also elsewhere on the board
L3: D6.C, R33.1
L4: D7.C, R32.1
LED_1: D4.A; also elsewhere on the board
LED_2: D5.A; also elsewhere on the board
LED_3: D6.A; also elsewhere on the board
LED_4: D7.A; also elsewhere on the board
LED_GRN: GRN.A; also elsewhere on the board
LED_RED: RED.A; also elsewhere on the board
MDIR_1A: H1.21 (AIN1); also elsewhere on the board
MDIR_1B: H1.22 (AIN2); also elsewhere on the board
MDIR_2A: H1.17 (BIN1); also elsewhere on the board
MDIR_2B: H1.16 (BIN2); also elsewhere on the board
MDIR_3A: H2.21 (AIN1); also elsewhere on the board
MDIR_3B: H2.22 (AIN2); also elsewhere on the board
MDIR_4A: H2.17 (BIN1); also elsewhere on the board
MDIR_4B: H2.16 (BIN2); also elsewhere on the board
MODE_BTN: MODE.2; also elsewhere on the board
MOT1A: H1.1 (A01), H1.2 (A01), M1.P$2 (2)
MOT1B: H1.5 (A02), H1.6 (A02), M1.P$1 (1)
MOT2A: H1.11 (B01), H1.12 (B01), M2.P$1 (1)
MOT2B: H1.7 (B02), H1.8 (B02), M2.P$2 (2)
MOT3A: H2.1 (A01), H2.2 (A01), M3.P$1 (1)
MOT3B: H2.5 (A02), H2.6 (A02), M3.P$2 (2)
MOT4A: H2.11 (B01), H2.12 (B01), M4.P$2 (2)
MOT4B: H2.7 (B02), H2.8 (B02), M4.P$1 (1)
MOT_STBY: H1.19 (STBY), H2.19 (STBY); also elsewhere on the board
unnamed: R36.2, U$1.P$1 (1)
unnamed: GRN.C, R22.1
unnamed: BAL.2 (VC1), C17.1, C18.2, R30.2
unnamed: R21.1, RED.C
unnamed: BAL.1 (VC2), C17.2, R28.2
unnamed: 6V_REG.7 (SS), C21.2
unnamed: C15.2, PROT.5 (VDD), R44.2
unnamed: C6.1, IMU.10 (REGOUT)
unnamed: C14.1, CHGIC.15 (BST)
unnamed: 5VREG.2 (OUT), D1.C, L1.1
unnamed: CHG.C, R3.2
unnamed: CHGIC.11 (CHGOK), R3.1
unnamed: BAL.4 (CD), C19.1
unnamed: R37.2, U$1.P$2 (2)
unnamed: BAL.7 (VDD), C1.1, R34.2
unnamed: R38.2, U$1.P$3 (3)
unnamed: R39.2, U$1.P$4 (4)
unnamed: D5.C, R29.1
unnamed: D4.C, R31.1
unnamed: BAL.3 (VC1_CB), R27.2
unnamed: R40.2, U$1.P$5 (5)
unnamed: R41.2, U$1.P$6 (6)
unnamed: 6V_REG.2 (BS), C22.1
unnamed: R42.2, U$1.P$19 (7)
unnamed: C14.2, CHGIC.1 (SW), L2.1
unnamed: R43.2, U$1.P$20 (8)
unnamed: 6V_REG.1 (LX), C22.2, D9.C, L3.1
unnamed: 6V_REG.4 (FSW), R47.2
unnamed: C23.2, L3.2, R49.2, U$1.P$7 (PWR), U$1.P$8 (PWR), U$1.P$9 (PWR), U$1.P$10 (PWR), U$1.P$11 (PWR), U$1.P$12 (PWR), U$1.P$21 (PWR), U$1.P$22 (PWR)
unnamed: 6V_REG.5 (COMP), R45.2
unnamed: 6V_REG.6 (FB), R48.2, R49.1
unnamed: C24.2, R45.1
unnamed: CHGIC.10 (CSP), L2.2, R4.2
unnamed: C10.2, CHGIC.14 (TMR)
unnamed: CHGIC.13 (NTC), R5.1, R6.2
unnamed: 5VREG.1 (VIN), C3.1, D2.C, D3.C
PAUSE_BTN: PAUSE.2; also elsewhere on the board
PWM_1A: H1.23 (PWMA); also elsewhere on the board
PWM_1B: H1.15 (PWMB); also elsewhere on the board
PWM_2A: H2.23 (PWMA); also elsewhere on the board
PWM_2B: H2.15 (PWMB); also elsewhere on the board
PWR: POWER.2; also elsewhere on the board
QEP_0A: E1.3, R20.1; also elsewhere on the board
QEP_0B: E1.4, R18.1; also elsewhere on the board
QEP_1A: E2.3, R17.1; also elsewhere on the board
QEP_1B: E2.4, R16.1; also elsewhere on the board
QEP_2A: E3.3, R15.1; also elsewhere on the board
QEP_2B: E3.4, R9.1; also elsewhere on the board
QEP_4A: E4.3, R35.1; also elsewhere on the board
QEP_4B: E4.4, R26.1; also elsewhere on the board
RESET: RESET.2; also elsewhere on the board
SERVO_EN: 6V_REG.8 (EN), R46.2; also elsewhere on the board
SPI1_MISO: SPI1.1.4, SPI1.2.4; also elsewhere on the board
SPI1_MOSI: SPI1.1.3, SPI1.2.3; also elsewhere on the board
SPI1_SCK: SPI1.1.5, SPI1.2.5; also elsewhere on the board
SPI1_SS1: SPI1.1.6; also elsewhere on the board
SPI1_SS2: SPI1.2.6; also elsewhere on the board
SVO1: R36.1, R50.1; also elsewhere on the board
SVO2: R37.1, R51.1; also elsewhere on the board
SVO3: R38.1, R52.1; also elsewhere on the board
SVO4: R39.1, R53.1; also elsewhere on the board
SVO5: R40.1, R54.2; also elsewhere on the board
SVO6: R41.1, R55.2; also elsewhere on the board
SVO7: R42.1, R56.2; also elsewhere on the board
SVO8: R43.1, R57.2; also elsewhere on the board
UART0_RX: UART0.3; also elsewhere on the board
UART0_TX: UART0.4; also elsewhere on the board
UART1_RX: UART1.3; also elsewhere on the board
UART1_TX: UART1.4; also elsewhere on the board
UART2_RX: GPS.3; also elsewhere on the board
UART2_TX: GPS.4; also elsewhere on the board
UART4_RX: DSM2.3; also elsewhere on the board
UART5_RX: UART5.3; also elsewhere on the board
UART5_TX: UART5.4; also elsewhere on the board
VCC: C7.1, C12.1, CHG.A, CHGIC.2 (VIN), D3.A, JACK.1, R1.1
VCC_CHG: C4.2, CHGIC.3 (VCC), CHGIC.5 (SEL), R5.2
VDD_ADC: ADC.2; also elsewhere on the board
V_BATT: 6V_REG.9 (VIN), C11.+, C20.2, C25.1, C26.1, CHGIC.9 (BATT), D2.A, H1.13 (VM2), H1.14 (VM3), H1.24 (VM1), H2.13 (VM2), H2.14 (VM3), H2.24 (VM1), LIPO.P$1 (1), R4.1, R19.1, R28.1, R34.1
V_DIV_BAT: R19.2, R25.1; also elsewhere on the board
V_DIV_DC: R1.2, R14.1; also elsewhere on the board

Notes on the sheet:
BeagleBoard.org BeagleBone Blue Rev. -
Barrel Connector Center Positive 5.5x2.1mm
ADC Dividers
Prototyping Power Rails
Buttons and LEDs
eQEP Encoder Plugs JST SH
I2C Pullups
2A 5V Regulator
Overcharge Protection at 4.3V Overcharge timeout td = C19 * 9.0s/uF = 0.9 seconds Discharge Protection at 2.5V CHG_EN goes HIGH to disable charger
I_chg = 1kV / R6 * R4 = 1000mA
Battery Indicator LEDs
MOTOR DRIVERS
Servo Connectors & Power Control
JST-ZH
Barometer
Charger
JST-ZH Connectors
IMU 9-Axis
For EM-506 GPS Style Connector
2S Lithium Balancer and Protection
red
green
JST-SH
JST XH
Battery Connector
Serial and Analog Connections
Servo Pulldowns
2S LiPo Charger
0.1 Ohm resistor for 1A charge
CELL pin left open: 2S SEL pin pulled HIGH: charge to 4.1V per cell
This schematic is *NOT SUPPORTED* and DOES NOT constitute a reference design. Only *community* support is allowed via resources at BeagleBoard.org/discuss. THERE IS NO WARRANTY FOR THIS DESIGN, TO THE EXTENT PERMITTED BY APPLICABLE LAW. EXCEPT WHEN OTHERWISE STATED IN WRITING THE COPYRIGHT HOLDERS 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
This work is licensed under a Creative Commons Attribution-ShareAlike 3.0 United States License.
