# Repository jadonk/beaglebone-blue

File README.md:

# BeagleBoard.org BeagleBone Blue
_BeagleBone optimized for robotics and machine control_

Home on Github: https://github.com/beagleboard/beaglebone-blue

To optimize BeagleBone for education, BeagleBone Blue was created that integrates many components for robotics and machine control, including connectors for off-the-shelf robotic components. For education, this means you can quickly start talking about topics such as programming and control theory, without needing to spend so much time on electronics. The goal is to still be very hackable for learning electronics as well, including being fully open hardware.

BeagleBone Blue's legacy is primarily from contributions to BeagleBone Black robotics by [UCSD Flow Control and Coordinated Robotics Lab](http://robotics.ucsd.edu/), [Strawson Design](http://www.strawsondesign.com/), [Octavo Systems](http://octavosystems.com), [WowWee](http://www.wowwee.com/mip/), [National Instruments LabVIEW](http://www.ni.com/labview/) and of course the [BeagleBoard.org Foundation](https://beagleboard.org/about).

# Terms
These design materials are *NOT SUPPORTED* and *DO NOT* constitute a reference design. Only “community” support is allowed via resources at [BeagleBoard.org/discuss](https://beagleboard.org/discuss).

THERE IS NO WARRANTY FOR THE DESIGN MATERIALS, TO THE EXTENT PERMITTED BY APPLICABLE LAW. EXCEPT WHEN OTHERWISE STATED IN WRITING THE COPYRIGHT HOLDERS AND/OR OTHER PARTIES PROVIDE THE DESIGN MATERIALS “AS IS” WITHOUT WARRANTY OF ANY KIND, EITHER EXPRESSED OR IMPLIED, INCLUDING, BUT NOT LIMITED TO, THE IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE. THE ENTIRE RISK AS TO THE QUALITY AND PERFORMANCE OF THE DESIGN MATERIALS IS WITH YOU. SHOULD THE DESIGN MATERIALS PROVE DEFECTIVE, YOU ASSUME THE COST OF ALL NECESSARY SERVICING, REPAIR OR CORRECTION.

In other words, you may use the design materials as you choose and there is no license with regards to usage in the manufacturing process. We mean it, these design materials may be totally unsuitable for any purposes. Don't blame us!

As a general rule, we don't encourage use of this or other off-the-shelf single board computers in commercial products without engaging with a manufacturer to create a supplier agreement and make sure that you can get material as your business demands. Further, we do update the design on occasions where we find it necessary and won't guarantee a supply of older revisions, though we do seek periodic manufacturing of all of our boards for a period of roughly 10 years and will make design changes to replace obsolete parts and that may impact your usage. If you do opt to use it in a product, you take full responsibility for that product.

Do not use the BeagleBoard.org logo or trademarks (such as BeagleBoard and BeagleBone) on your products without a [logo license](https://beagleboard.org/logo) from the BeagleBoard.org Foundation, but feel free to reference BeagleBoard.org.

See the [LICENSE](https://github.com/beagleboard/beaglebone-blue/blob/master/LICENSE) file regarding the copyright of these materials.

## EAGLE design EAGLE/BeagleBone_Blue.brd

Parts:
0, 1, 2, 3: BLUE; BEAGLEBONE_BLUE_LED-0603
5VREG: AP1509SOIC-8-TIGHT; BEAGLEBONE_BLUE_SO08-TIGHT
6VREG: AOZ1284; SO08-EXPOSED
12V: PJ-102B_POWER_CON
ADC: JST_SH_6
B0: RED; LED-0603
B1, B2, B3: GREEN; LED-0603
BAL: BQ29209; 8-SON_3X3MM
BMP: BMP280
C1, C2, C6, C8, C9, C13, C14, C15, C17, C18, C19, C21, C22, C24: 0.1uF; 0402-CAP
C3, C5, C7, C12, C16, C20, C23, C25, C26: 10uF; 0805
C4, C10: 1uF; 0402-CAP
C11: 100uF 16V; PANASONIC_D
CAN: JST_SH_4; JST_SH_4_SMD
CHG: GRN; LED-0603
CHGIC: MP2615
D1, D2, D3: DIODE_SOD-123FL; ADAFRUIT_SOD-123FL
D9: DIODEDO214AA; DO-214AA
DSM2: JST_ZH_3
E1, E2, E3, E4: JST_SH_4; JST_SH_4_SMD
G: GREEN; BEAGLEBONE_BLUE_LED-0603
GP0, GP1: JST_SH_6
GPS: JST_SH_6
H1, H2: TB6621FNG; SSOP24
I2C: JST_SH_4; JST_SH_4_SMD
IMU: MPU-9250; QFN24G-0.4-3X3MM
J2: STRAWSON_EAGLE_LIB_SERVO_HEADERS_8X; STRAWSON_EAGLE_LIB_3X8_0.1"_HEADER
L1, L2: 6.8uH; SRN6045
L3: 3.6 uH; 8X8MM_INDUCTOR
LIPO: BATTERY; JST_XH_3-PIN
M1, M2, M3, M4: JST_ZH_2
MOD: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
PAU: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
POW: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
PROT: S-8261; SOT-236
PWR: JST_SH_4; JST_SH_4_SMD
Q1: MOSFET-N; SO08-TIGHT
R: RED; BEAGLEBONE_BLUE_LED-0603
R1, R19, R45: 47k; 0402-RES
R3, R44: 1k; 0402-RES
R4: 0.1; 0603-RES
R5, R6, R8, R48: 10k; 0402-RES
R7, R10, R11, R12, R13, R14, R25, R36, R37, R38, R39, R40, R41, R42, R43, R50, R51, R52, R53: 4.7k; 0402-RES
R21, R22, R29, R30, R31, R32, R33, R91: 240; 0402-RES
R27, R28, R34: 150; 0402-RES
R46, R61, R62, R63, R64: 1K; 0402-RES
R47: 100k; 0402-RES
R49: 65k; 0402-RES
R107: .1, 0805; R0805
RST: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
S1.1, S1.2: JST_SH_6
SD: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
UT0, UT1, UT5: JST_SH_4; JST_SH_4_SMD
WIFI: GREEN; BEAGLEBONE_BLUE_LED-0603

Connections:
3.3V: BMP.2 (CSB), BMP.6 (VDDIO), BMP.8 (VDD), C2.2, C8.1, C9.2, C13.1, C16.1, CAN.2, DSM2.P$1 (1), E1.2, E2.2, E3.2, E4.2, GP0.2, GP1.2, H1.20 (VCC), H2.20 (VCC), I2C.2, IMU.1 (RESV), IMU.8 (VDDIO), IMU.13 (VDD), IMU.22 (NCS), PWR.3, R10.1, R11.2, R12.2, R13.1, S1.1.2, S1.2.2, UT0.2, UT1.2, UT5.2; also elsewhere on the board
5.0V: 5VREG.3 (FB), C5.1, GPS.5, L1.2, PWR.4; also elsewhere on the board
AIN0: ADC.3; also elsewhere on the board
AIN1: ADC.4; also elsewhere on the board
AIN2: ADC.5; also elsewhere on the board
AIN3: ADC.6; also elsewhere on the board
BATT_LED_1: B0.A; also elsewhere on the board
BATT_LED_2: B1.A; also elsewhere on the board
BATT_LED_3: B2.A; also elsewhere on the board
BATT_LED_4: B3.A; also elsewhere on the board
BATT_MID: LIPO.P$2 (2), R27.1, R30.1, R44.1
BATT_MINUS: BAL.5 (GND), BAL.6 (CB_EN), C1.2, C15.1, C18.1, C19.2, LIPO.P$3 (3), PROT.2 (VM), PROT.6 (VSS), Q1.1 (S), Q1.2 (S), Q1.3 (S)
CANH: CAN.3; also elsewhere on the board
CANL: CAN.4; also elsewhere on the board
CGND: R107.2; also elsewhere on the board
CHG_EN: CHGIC.6 (EN), R7.2, R8.1
CO: BAL.8 (OUT), R7.1
DO: PROT.1 (DO), Q1.4 (G)
EQEP_0A: E1.3; also elsewhere on the board
EQEP_0B: E1.4; also elsewhere on the board
EQEP_1A: E2.3; also elsewhere on the board
EQEP_1B: E2.4; also elsewhere on the board
EQEP_2A: E3.3; also elsewhere on the board
EQEP_2B: E3.4; also elsewhere on the board
GND: 5VREG.4 (SD), 5VREG.5 (GND), 5VREG.6 (GND1), 5VREG.7 (GND2), 5VREG.8 (GND3), 6VREG.3 (GND), 12V.OUT, ADC.1, BMP.1 (GND), BMP.5 (SDO), BMP.7 (GND), C2.1, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.-, C12.2, C13.2, C16.2, C20.1, C21.1, C23.1, C24.1, C25.2, C26.2, CAN.1, CHGIC.8 (AGND), CHGIC.16 (PGND), D1.A, D9.A, DSM2.P$2 (2), E1.1, E2.1, E3.1, E4.1, GP0.1, GP1.1, GPS.2, GPS.6, H1.3 (PGND1), H1.4 (PGND1), H1.9 (PGND2), H1.10 (PGND2), H1.18 (GND), H2.3 (PGND1), H2.4 (PGND1), H2.9 (PGND2), H2.10 (PGND2), H2.18 (GND), I2C.1, IMU.9 (AD0/SDO), IMU.18 (GND), IMU.20 (RESV), J2.P$13 (GND), J2.P$14 (GND), J2.P$15 (GND), J2.P$16 (GND), J2.P$17 (GND), J2.P$18 (GND), J2.P$23 (GND), J2.P$24 (GND), MOD.1, PAU.1, POW.1, PWR.1, PWR.2, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), R6.1, R8.2, R14.2, R21.2, R22.2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; also elsewhere on the board
GPIO1_17: GP0.4; also elsewhere on the board
GPIO1_25: GP0.3; also elsewhere on the board
GPIO3_1: GP1.4; also elsewhere on the board
GPIO3_2: GP1.3; also elsewhere on the board
GPIO3_17: GP0.6; also elsewhere on the board
GPIO3_20: GP0.5; also elsewhere on the board
I2C1_SCL: I2C.3, R12.1; also elsewhere on the board
I2C1_SDA: I2C.4, R13.2; also elsewhere on the board
I2C2_SCL: BMP.4 (SCK), IMU.23 (SCL/SCLK), R11.1; also elsewhere on the board
I2C2_SDA: BMP.3 (SDI), IMU.24 (SDA/SDI), R10.2; also elsewhere on the board
IMU_INT: IMU.12 (INT); also elsewhere on the board
L3: B2.C, R33.1
L4: B3.C, R32.1
LED_GRN: G.A, GP1.6; also elsewhere on the board
LED_RED: GP1.5, R.A; also elsewhere on the board
MDIR_1A: H1.21 (AIN1); also elsewhere on the board
MDIR_1B: H1.22 (AIN2); also elsewhere on the board
MDIR_2A: H1.17 (BIN1); also elsewhere on the board
MDIR_2B: H1.16 (BIN2); also elsewhere on the board
MDIR_3A: H2.21 (AIN1); also elsewhere on the board
MDIR_3B: H2.22 (AIN2); also elsewhere on the board
MDIR_4A: H2.17 (BIN1); also elsewhere on the board
MDIR_4B: H2.16 (BIN2); also elsewhere on the board
MODE_BTN: MOD.2; also elsewhere on the board
MOT1A: H1.1 (A01), H1.2 (A01), M1.P$2 (2)
MOT1B: H1.5 (A02), H1.6 (A02), M1.P$1 (1)
MOT2A: H1.11 (B01), H1.12 (B01), M2.P$1 (1)
MOT2B: H1.7 (B02), H1.8 (B02), M2.P$2 (2)
MOT3A: H2.1 (A01), H2.2 (A01), M3.P$1 (1)
MOT3B: H2.5 (A02), H2.6 (A02), M3.P$2 (2)
MOT4A: H2.11 (B01), H2.12 (B01), M4.P$2 (2)
MOT4B: H2.7 (B02), H2.8 (B02), M4.P$1 (1)
MOT_STBY: H1.19 (STBY), H2.19 (STBY); also elsewhere on the board
unnamed: J2.P$1 (1), R36.2
unnamed: G.C, R22.1
unnamed: BAL.2 (VC1), C17.1, C18.2, R30.2
unnamed: R.C, R21.1
unnamed: BAL.1 (VC2), C17.2, R28.2
unnamed: 6VREG.7 (SS), C21.2
unnamed: C15.2, PROT.5 (VDD), R44.2
unnamed: C6.1, IMU.10 (REGOUT)
unnamed: C14.1, CHGIC.15 (BST)
unnamed: 5VREG.2 (OUT), D1.C, L1.1
unnamed: CHG.C, R3.2
unnamed: CHGIC.11 (CHGOK), R3.1
unnamed: R91.1, WIFI.C
unnamed: BAL.4 (CD), C19.1
unnamed: J2.P$2 (2), R37.2
unnamed: BAL.7 (VDD), C1.1, R34.2
unnamed: J2.P$3 (3), R38.2
unnamed: J2.P$4 (4), R39.2
unnamed: 0.C, R61.2
unnamed: B1.C, R29.1
unnamed: B0.C, R31.1
unnamed: BAL.3 (VC1_CB), R27.2
unnamed: J2.P$5 (5), R40.2
unnamed: J2.P$6 (6), R41.2
unnamed: 6VREG.2 (BS), C22.1
unnamed: J2.P$19 (7), R42.2
unnamed: C14.2, CHGIC.1 (SW), L2.1
unnamed: J2.P$20 (8), R43.2
unnamed: 1.C, R62.2
unnamed: 2.C, R63.2
unnamed: 3.C, R64.2
unnamed: 6VREG.1 (LX), C22.2, D9.C, L3.1
unnamed: 6VREG.4 (FSW), R47.2
unnamed: C23.2, J2.P$7 (PWR), J2.P$8 (PWR), J2.P$9 (PWR), J2.P$10 (PWR), J2.P$11 (PWR), J2.P$12 (PWR), J2.P$21 (PWR), J2.P$22 (PWR), L3.2, R49.2
unnamed: 6VREG.5 (COMP), R45.2
unnamed: 6VREG.6 (FB), R48.2, R49.1
unnamed: C24.2, R45.1
unnamed: CHGIC.10 (CSP), L2.2, R4.2
unnamed: C10.2, CHGIC.14 (TMR)
unnamed: CHGIC.13 (NTC), R5.1, R6.2
unnamed: 5VREG.1 (VIN), C3.1, D2.C, D3.C
PAUSE_BTN: PAU.2; also elsewhere on the board
POWER_BTN: POW.2; also elsewhere on the board
PRU_E_A: E4.3; also elsewhere on the board
PRU_E_B: E4.4; also elsewhere on the board
PWM_1A: H1.23 (PWMA); also elsewhere on the board
PWM_1B: H1.15 (PWMB); also elsewhere on the board
PWM_2A: H2.23 (PWMA); also elsewhere on the board
PWM_2B: H2.15 (PWMB); also elsewhere on the board
RESET: RST.2; also elsewhere on the board
SD_BOOT: SD.2; also elsewhere on the board
SERVO_EN: 6VREG.8 (EN), R46.2; also elsewhere on the board
SPI1_MISO: S1.1.4, S1.2.4; also elsewhere on the board
SPI1_MOSI: S1.1.3, S1.2.3; also elsewhere on the board
SPI1_SCK: S1.1.5, S1.2.5; also elsewhere on the board
SPI1_SS1: S1.1.6; also elsewhere on the board
SPI1_SS2: S1.2.6; also elsewhere on the board
SVO1: R36.1, R50.1; also elsewhere on the board
SVO2: R37.1, R51.1; also elsewhere on the board
SVO3: R38.1, R52.1; also elsewhere on the board
SVO4: R39.1, R53.1; also elsewhere on the board
SVO5: R40.1; also elsewhere on the board
SVO6: R41.1; also elsewhere on the board
SVO7: R42.1; also elsewhere on the board
SVO8: R43.1; also elsewhere on the board
UART0_RX: UT0.3; also elsewhere on the board
UART0_TX: UT0.4; also elsewhere on the board
UART1_RX: UT1.3; also elsewhere on the board
UART1_TX: UT1.4; also elsewhere on the board
UART2_RX: GPS.3; also elsewhere on the board
UART2_TX: GPS.4; also elsewhere on the board
UART4_RX: DSM2.P$3 (3); also elsewhere on the board
UART5_RX: UT5.3; also elsewhere on the board
UART5_TX: UT5.4; also elsewhere on the board
USR_LED0: 0.A; also elsewhere on the board
USR_LED1: 1.A; also elsewhere on the board
USR_LED2: 2.A; also elsewhere on the board
USR_LED3: 3.A; also elsewhere on the board
VCC: 12V.IN, C7.1, C12.1, CHG.A, CHGIC.2 (VIN), D3.A, R1.1
VCC_CHG: C4.2, CHGIC.3 (VCC), R5.2
VDD_ADC: ADC.2; also elsewhere on the board
V_BATT: 6VREG.9 (VIN), C11.+, C20.2, C25.1, C26.1, CHGIC.9 (BATT), D2.A, H1.13 (VM2), H1.14 (VM3), H1.24 (VM1), H2.13 (VM2), H2.14 (VM3), H2.24 (VM1), LIPO.P$1 (1), R4.1, R19.1, R28.1, R34.1
V_DIV_BAT: R19.2, R25.1; also elsewhere on the board
V_DIV_DC: R1.2, R14.1; also elsewhere on the board
WIFI_LED: WIFI.A; also elsewhere on the board

Notes on the sheet:
BeagleBoard.org BeagleBone Blue Rev. A2
Barrel Connector Center Positive 5.5x2.1mm
ADC Dividers
Prototyping Power Rails
Buttons and LEDs
eQEP Encoder Plugs JST SH
I2C Pullups
2A 5V Regulator
Overcharge Protection at 4.3V Overcharge timeout td = C19 * 9.0s/uF = 0.9 seconds Discharge Protection at 2.5V CHG_EN goes HIGH to disable charger
I_chg = 1kV / R6 * R4 = 1000mA
Battery Indicator LEDs
MOTOR DRIVERS
Servo Connectors & Power Control
JST-ZH
Barometer
Charger
JST-ZH Connectors
IMU 9-Axis
For EM-506 GPS Style Connector
2S Lithium Balancer and Protection
red
grn
JST XH
Battery Connector
JST-SH
Serial and Analog Connections
Servo Pulldowns
2S LiPo Charger
0.1 Ohm resistor for 1A charge
CELL pin left open: 2S SEL pin left open, 4.2V per cell
This schematic is *NOT SUPPORTED* and DOES NOT constitute a reference design. Only *community* support is allowed via resources at BeagleBoard.org/discuss. THERE IS NO WARRANTY FOR THIS DESIGN, TO THE EXTENT PERMITTED BY APPLICABLE LAW. EXCEPT WHEN OTHERWISE STATED IN WRITING THE COPYRIGHT HOLDERS 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
This work is licensed under a Creative Commons Attribution-ShareAlike 3.0 United States License.
User LEDs
blue
EQEP_1A, EQEP_1B: 100K pull down Pg 3.
SVO5 - SVO8 are bootmode pins. See Pg 3 for PU/PDs

Parts:
C27, C28, C35, C37, C39, C40, C41: 0.1uF; 0402-CAP
C29, C30, C31, C32: 10pF; 0402-CAP
C33, C36: 2.2uF; 0402-CAP
C34, C38: 10uF; 0805
EMU0, EMU1: TPSQB1,27; B1,27
GND: GHI2_TESTPAD/W_HOLE_1X1
ON: BLUE; BEAGLEBONE_BLUE_LED-0603
R2, R23, R58: 1.5K; 0402-RES
R15: 33; 0402-RES
R18, R20: 1M; 0402-RES
R24, R59: 4.7k; 0402-RES
R26, R35, R54, R55, R56, R57, R60, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R94: 10K; 0402-RES
R104: 120, DNP; 0603-RES
SIP: OSD3358; BEAGLEBONE_BLUE_OSD3358
TCK: TPSQB1,27; B1,27
TDI: TPSQB1,27; B1,27
TDO: TPSQB1,27; B1,27
TMS: TPSQB1,27; B1,27
TP1, TP12: TPSQB1,27; B1,27
TP5: TPB0,65; BEAGLEBONE_BLUE_B0,65
TRSTN: TPSQB1,27; B1,27
U1: TCAN1051HV; BEAGLEBONE_BLUE_D8
U5: 24LC_32AT-I/OT; SOT95P290X145-5N
U6: SN74LVC1G07_DCK_5; BEAGLEBONE_BLUE_DCK5
U13: EMMC; MICRON_EMMC_153
WP: GHI2_TESTPAD/W_HOLE_1X1
X2: SCHA5B0200
Y1: 24 MHz; CRYSTAL_5X3.2MM
Y2: 32.768kHz; CRYSTAL_3.2X1.5

Connections:
3.3V: C27.1, C28.1, C34.2, C35.2, C37.1, C38.1, C39.1, C40.1, C41.1, R2.2, R23.2, R26.2, R35.2, R54.2, R55.2, R56.2, R57.2, R58.2, R60.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R94.2, SIP.U20 (VOUT_USER_3P3V_0), SIP.V20 (VOUT_USER_3P3V_1), U1.5 (VIO), U5.4 (VCC), U13.C6 (VCCQ1), U13.E6 (VCC1), U13.F5 (VCC2), U13.J10 (VCC3), U13.K9 (VCC4), U13.M4 (VCCQ2), U13.N4 (VCCQ3), U13.P3 (VCCQ4), U13.P5 (VCCQ5), X2.4 (VDD); also elsewhere on the board
5.0V: SIP.Y5 (VIN_AC_0), SIP.Y6 (VIN_AC_1); also elsewhere on the board
BATT_LED_1: SIP.U12 (GPIO0_27_U12); also elsewhere on the board
BATT_LED_3: SIP.V6 (GPIO1_29_V6); also elsewhere on the board
BATT_LED_4: SIP.T11 (GPIO0_26_T11); also elsewhere on the board
CANH: R104.1, U1.7 (CANH); also elsewhere on the board
CANL: R104.2, U1.6 (CANL); also elsewhere on the board
CGND: X2.CGND1, X2.CGND2, X2.CGND3, X2.CGND4, X2.CGND5, X2.CGND6; also elsewhere on the board
DCAN1_RX: SIP.E17 (UART0_RTSN_E17), U1.4 (RXD)
DCAN1_SILENT: U1.8 (S); also elsewhere on the board
DCAN1_TX: SIP.E18 (UART0_CTSN_E18), U1.1 (TXD)
EMMC_RST: R94.1, SIP.R14 (EMMCRST_GPIO1_20_R14), U13.K5 (RST#)
EQEP_0A: SIP.B12 (GPIO3_18_B12); also elsewhere on the board
EQEP_0B: SIP.C13 (GPIO3_19_C13); also elsewhere on the board
EQEP_2A: SIP.T12 (GPIO1_12_T12); also elsewhere on the board
EQEP_2B: SIP.R12 (GPIO1_13_R12); also elsewhere on the board
GND: C27.2, C28.2, C33.2, C34.1, C35.1, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, GND.P$1, R24.2, R59.1, TP12.TP, U1.2 (GND), U5.2 (VSS), U6.3 (GND), U13.C4 (VSSQ1), U13.E7 (VSS1), U13.G5 (VSS2), U13.H10 (VSS3), U13.K8 (VSS4), U13.N2 (VSSQ2), U13.N5 (VSSQ3), U13.P4 (VSSQ4), U13.P6 (VSSQ5), X2.6 (VSS), X2.GND; also elsewhere on the board
GPIO1_17: SIP.V14 (GPIO1_17_V14); also elsewhere on the board
GPIO3_17: SIP.C12 (SPI1_CS0_C12); also elsewhere on the board
GPIO3_20: SIP.D13 (GPIO3_20_D13); also elsewhere on the board
I2C0_SCL: R23.1, SIP.C16 (I2C0_SCL), SIP.C20 (PMIC_I2C_SCL), U5.1 (SCL)
I2C0_SDA: R2.1, SIP.C17 (I2C0_SDA), SIP.C19 (PMIC_I2C_SDA), U5.3 (SDA)
I2C1_SCL: SIP.A16 (I2C1_SCL_A16); also elsewhere on the board
I2C1_SDA: SIP.B16 (I2C1_SDA_B16); also elsewhere on the board
I2C2_SCL: SIP.D17 (I2C2_SCL_D17); also elsewhere on the board
I2C2_SDA: SIP.D18 (I2C2_SDA_D18); also elsewhere on the board
IMU_INT: SIP.A14 (GPIO3_21_A14); also elsewhere on the board
LDO_PGOOD: SIP.B5 (RTC_PWRONRSTN), SIP.B20 (PMIC_OUT_LDO_PGOOD)
LED_GRN: SIP.T7 (TIMER7_T7); also elsewhere on the board
LED_RED: SIP.R7 (TIMER4_R7); also elsewhere on the board
MCASP0_ACLKR: SIP.U18 (GPIO1_28_U18); also elsewhere on the board
MCASP0_FSR: SIP.V12 (GPIO2_1_V12); also elsewhere on the board
MDIR_1A: SIP.T13 (GPIO2_0_T13); also elsewhere on the board
MDIR_1B: SIP.U17 (UART4_TXD_U17); also elsewhere on the board
MDIR_2A: SIP.R13 (GPIO1_16_R13); also elsewhere on the board
MMC1_CLK: R15.2, R66.1, U13.M6 (CLK)
MMC1_CMD: R67.1, SIP.V9 (MMC1_CMD_V9), U13.M5 (CMD)
MMC1_DAT0: R68.1, SIP.U7 (MMC1_DAT0_U7), U13.A3 (DAT0)
MMC1_DAT1: R69.1, SIP.V7 (MMC1_DAT1_V7), U13.A4 (DAT1)
MMC1_DAT2: R70.1, SIP.R8 (MMC1_DAT2_R8), U13.A5 (DAT2)
MMC1_DAT3: R71.1, SIP.T8 (MMC1_DAT3_T8), U13.B2 (DAT3)
MMC1_DAT4: R72.1, SIP.U8 (MMC1_DAT4_U8), U13.B3 (DAT4)
MMC1_DAT5: R73.1, SIP.V8 (MMC1_DAT5_V8), U13.B4 (DAT5)
MMC1_DAT6: R74.1, SIP.R9 (MMC1_DAT6_R9), U13.B5 (DAT6)
MMC1_DAT7: R75.1, SIP.T9 (MMC1_DAT7_T9), U13.B6 (DAT7)
MODE_BTN: SIP.U6 (TIMER6_U6); also elsewhere on the board
MOT_STBY: SIP.D14 (GPIO0_20_D14); also elsewhere on the board
unnamed: R57.1, SIP.G17 (MMC0_CLK_G17), X2.5 (CLK)
unnamed: R26.1, SIP.F17 (MMC0_DAT3_F17), X2.2 (DAT3/CS)
unnamed: SIP.C6 (PMIC_POWER_EN), SIP.D19 (PMIC_IN_PWR_EN), TP5.TP
unnamed: C30.1, R20.2, SIP.M20 (OSC0_IN), Y1.2
unnamed: C29.1, R20.1, SIP.K20 (OSC0_OUT), Y1.1
unnamed: R58.1, U5.5 (WP), WP.P$1
unnamed: C29.2, C30.2, SIP.L20 (OSC0_GND)
unnamed: C31.1, R18.2, SIP.H20 (OSC1_IN), Y2.P$2
unnamed: C32.2, R18.1, SIP.F20 (OSC1_OUT), Y2.P$1
unnamed: C31.2, C32.1, SIP.G20 (OSC1_GND)
unnamed: EMU0.TP, SIP.B14 (JTAG_EMU1)
unnamed: EMU1.TP, SIP.C14 (JTAG_EMU0)
unnamed: SIP.A11 (JTAG_TDO), TDO.TP
unnamed: SIP.A12 (JTAG_TCK), TCK.TP
unnamed: SIP.B11 (JTAG_TDI), TDI.TP
unnamed: SIP.C11 (JTAG_TMS), TMS.TP
unnamed: R59.2, SIP.B10 (JTAG_TRSTN), TRSTN.TP
unnamed: R54.1, SIP.G15 (MMC0_DAT1_G15), X2.8 (DAT1)
unnamed: R56.1, SIP.G18 (MMC0_CMD_G18), X2.3 (CMD/DI)
unnamed: R65.1, SIP.C15 (MMC0_CD_C15), X2.CD (CD#)
unnamed: R55.1, SIP.G16 (MMC0_DAT0_G16), X2.7 (DAT0/DO)
unnamed: C36.1, U13.C2 (VDDI)
unnamed: R15.1, SIP.U9 (MMC1_CLK_U9)
NTE: R35.1, SIP.F18 (MMC0_DAT2_F18), X2.1 (DAT2)
PAUSE_BTN: SIP.T6 (TIMER5_T6); also elsewhere on the board
PMIC_INT: SIP.B18 (EXTINTN), SIP.B19 (PMIC_OUT_NINT)
PMIC_NWAKEUP: SIP.A19 (PMIC_OUT_NWAKEUP), SIP.C5 (EXT_WAKEUP)
PMIC_PGOOD: SIP.A20 (PMIC_OUT_PGOOD), SIP.B15 (PWRONRSTN), U6.2 (A)
POWER_BTN: SIP.D20 (PMIC_IN_PB_IN); also elsewhere on the board
PRU_E_A: SIP.V13 (GPIO1_14_V13); also elsewhere on the board
PRU_E_B: SIP.U13 (GPIO1_15_U13); also elsewhere on the board
PWM_1A: SIP.U14 (EHRPWM1A_U14); also elsewhere on the board
PWM_1B: SIP.T14 (EHRPWM1B_T14); also elsewhere on the board
PWM_2A: SIP.U10 (EHRPWM2A_U10); also elsewhere on the board
PWM_2B: SIP.T10 (EHRPWM2B_T10); also elsewhere on the board
PWR_LED: ON.C, R24.1
RESET: C33.1, R60.1, SIP.A10 (WARMRSTN), U6.4 (Y); also elsewhere on the board
SPI1_MISO: SIP.B13 (SPI1_D0_B13); also elsewhere on the board
SPI1_MOSI: SIP.D12 (SPI1_D1_D12); also elsewhere on the board
SPI1_SCK: SIP.A13 (SPI1_CLK_A13); also elsewhere on the board
SPI1_SS2: SIP.C18 (GPIO0_7_C18); also elsewhere on the board
SYS_5V: SIP.W4 (VOUT_SYS_5V_0), SIP.Y4 (VOUT_SYS_5V_1), TP1.TP, U1.3 (VCC); also elsewhere on the board
UART0_RX: SIP.E15 (UART0_RXD_E15); also elsewhere on the board
UART0_TX: SIP.E16 (UART0_TXD_E16); also elsewhere on the board
UART1_RX: SIP.D16 (UART1_RXD_D16); also elsewhere on the board
UART1_TX: SIP.D15 (UART1_TXD_D15); also elsewhere on the board
UART2_RX: SIP.A17 (UART2_RXD_A17); also elsewhere on the board
UART2_TX: SIP.B17 (UART2_TXD_B17); also elsewhere on the board
UART4_RX: SIP.T17 (UART4_RXD_T17); also elsewhere on the board
USB_DC: SIP.Y8 (VIN_USB_0), SIP.Y9 (VIN_USB_1); also elsewhere on the board
USR_LED0: SIP.V15 (USR0_V15); also elsewhere on the board
USR_LED1: SIP.U15 (USR1_U15); also elsewhere on the board
USR_LED2: SIP.T15 (USR2_T15); also elsewhere on the board
USR_LED3: SIP.V16 (USR3_V16); also elsewhere on the board
VDD_1V8: SIP.N16 (VOUT_LDO3_1P8V_0), SIP.R16 (VOUT_LDO3_1P8V_1); also elsewhere on the board
VDD_3V3AUX: ON.A, SIP.Y11 (VOUT_LDO2_3P3V)
VDD_RTC: U6.5 (VCC); also elsewhere on the board
VIN_BAT_0: SIP.Y2 (VIN_BAT_0)
VIN_BAT_1: SIP.Y3 (VIN_BAT_1)
WIFI_LED: SIP.A15 (GPIO0_19_A15); also elsewhere on the board

Parts:
C42: 1nF; 0402-CAP
C43, C44, C45, C54, C55: 0.1uF; 0402-CAP
C46: 10uF; 0805
C61: 1uF; 0402-CAP
C62, C63: 0.22uF; 0402-CAP
L4, L5: 120; L0603
R16, R17, R95, R113, R115, R116, R118, R120, R122, R125, R127, R129, R131, R135, R140, R143: 100K; 0402-RES
R76, R77, R156: 33; 0402-RES
R109, R110: 4.7k; 0402-RES
R111, R149, R150: 0; 0402-RES
R112: 0; 0603-RES
R119, R121: 0, DNP; 0603-RES
SIP: OSD3358; BEAGLEBONE_BLUE_OSD3358
U3, U4: TPD4S012DRY; SON-6(TI)-DRY
U8: TPS2105_DBV_5; DBV5
X3: USB1; USB_HOST_HORIZONTAL_W/CHASSIS_GND
X4: 10118192-0001LF; 10118192-0001LF(MICRO-USB-B-AMPHENOL-FCI)

Connections:
3.3V: R109.1, R116.2, R118.2, R120.2, R122.2, R140.2; also elsewhere on the board
5.0V: C63.1, R95.2, R119.2, U8.1 (EN), U8.5 (IN1); also elsewhere on the board
AIN0: SIP.B6 (AIN0); also elsewhere on the board
AIN1: SIP.C7 (AIN1); also elsewhere on the board
AIN2: SIP.B7 (AIN2); also elsewhere on the board
AIN3: SIP.A7 (AIN3); also elsewhere on the board
BATT_LED_2: R143.2, SIP.T5 (LCD_DATA15_T5); also elsewhere on the board
BT_EN: SIP.K17; also elsewhere on the board
CGND: X3.5 (CG1), X3.6 (CG2), X4.CGND1 (SGND1), X4.CGND2 (SGND2), X4.CGND3 (SGND3), X4.CGND4 (SGND4), X4.CGND5 (SGND5), X4.CGND6 (SGND6); also elsewhere on the board
DCAN1_SILENT: SIP.M16; also elsewhere on the board
EQEP_1A: R16.2, SIP.V2 (LCD_DATA12_V2); also elsewhere on the board
EQEP_1B: R17.2, SIP.V3 (LCD_DATA13_V3); also elsewhere on the board
GND: C45.2, C46.2, C54.2, C55.2, C61.1, C62.2, C63.2, L4.1, R16.1, R17.1, R95.1, R110.2, R113.1, R115.1, R125.1, R127.1, R129.1, R131.1, R135.1, R143.1, R150.2, U3.4 (GND), U4.4 (GND), U8.2 (GND), X4.GND; also elsewhere on the board
GNDA_ADC: C42.2, C43.2, C44.2, SIP.A6 (VSSA_ADC_0), SIP.A9 (VSSA_ADC_1), SIP.E8 (VSSA_ADC_2)
GPIO1_25: SIP.U16 (HDMIINT_GPIO1_25_U16); also elsewhere on the board
GPIO3_1: SIP.H17; also elsewhere on the board
GPIO3_2: SIP.J15; also elsewhere on the board
MCASP0_AXR0: SIP.T16 (USB1OC_GPIO1_26_T16); also elsewhere on the board
MCASP0_AXR1: SIP.V17 (HDMIDIS_GPIO1_27_V17); also elsewhere on the board
MDIR_2B: R140.1, SIP.V4 (LCD_DATA14_V4); also elsewhere on the board
MDIR_3A: R118.1, SIP.R4 (LCD_DATA3_R4); also elsewhere on the board
MDIR_3B: R77.1, R116.1, SIP.R3 (LCD_DATA2_R3); also elsewhere on the board
MDIR_4A: R113.2, SIP.R1 (LCD_DATA0_R1); also elsewhere on the board
MDIR_4B: R115.2, SIP.R2 (LCD_DATA1_R2); also elsewhere on the board
MMC2_CLK: R76.1; also elsewhere on the board
MMC2_CMD: SIP.J16; also elsewhere on the board
MMC2_DAT0: SIP.J17; also elsewhere on the board
MMC2_DAT1: SIP.J18; also elsewhere on the board
MMC2_DAT2: SIP.K15; also elsewhere on the board
MMC2_DAT3: SIP.H16; also elsewhere on the board
unnamed: R76.2, SIP.L15
unnamed: R135.2, SIP.U4 (LCD_DATA11_U4)
unnamed: C42.1, C43.1, R111.2, SIP.B9 (ADC_VREFP)
unnamed: R109.2, R110.1, SIP.C9 (AIN7)
unnamed: R149.1, SIP.P15 (USB0_VBUS)
unnamed: R150.1, SIP.P17 (USB1_ID)
unnamed: L4.2, X3.4 (GND)
unnamed: R156.1, SIP.T18 (USB1_VBUS)
unnamed: L5.2, X3.1 (VBUS)
SD_BOOT: R77.2; also elsewhere on the board
SERVO_EN: SIP.U3 (LCD_DATA10_U3); also elsewhere on the board
SPI1_SS1: SIP.H18; also elsewhere on the board
SVO1: SIP.U5 (LCD_VSYNC_U5); also elsewhere on the board
SVO2: SIP.V5 (LCD_PCLK_V5); also elsewhere on the board
SVO3: SIP.R5 (LCD_HSYNC_R5); also elsewhere on the board
SVO4: SIP.R6 (LCD_DE_R6); also elsewhere on the board
SVO5: R125.2, SIP.T3 (LCD_DATA6_T3); also elsewhere on the board
SVO6: R127.2, SIP.T4 (LCD_DATA7_T4); also elsewhere on the board
SVO7: R120.1, SIP.T1 (LCD_DATA4_T1); also elsewhere on the board
SVO8: R122.1, SIP.T2 (LCD_DATA5_T2); also elsewhere on the board
SYS_5V: C62.1, R121.2, U8.3 (IN2); also elsewhere on the board
UART3_CTSN: SIP.M17; also elsewhere on the board
UART3_RTSN: SIP.M18; also elsewhere on the board
UART3_RX: SIP.L17; also elsewhere on the board
UART3_TX: SIP.L16; also elsewhere on the board
UART5_RX: R131.2, SIP.U2 (LCD_DATA9_U2); also elsewhere on the board
UART5_TX: R129.2, SIP.U1 (LCD_DATA8_U1); also elsewhere on the board
USB0_D_N: SIP.N18 (USB0_DM), U3.2 (D-), X4.D-
USB0_D_P: SIP.N17 (USB0_DP), U3.1 (D+), X4.D+
USB0_ID: SIP.P16 (USB0_ID), U3.3 (ID), X4.ID
USB0_VBUS: C54.1, R112.2, R149.2, U3.6 (VBUS), X4.VBUS
USB1_D_N: SIP.R18 (USB1_DM), U4.2 (D-), X3.2 (D-)
USB1_D_P: SIP.R17 (USB1_DP), U4.1 (D+), X3.3 (D+)
USB1_VBUS: C45.1, C46.1, C55.1, C61.2, L5.1, R119.1, R121.1, R156.2, U4.6 (VBUS), U8.4 (OUT)
USB_DC: R112.1; also elsewhere on the board
VDD_ADC: C44.1, R111.1, SIP.A4 (VOUT_ADC_1P8V_0), SIP.A5 (VOUT_ADC_1P8V_1); also elsewhere on the board
VIN_BAT_0: SIP.Y2 (VIN_BAT_0)
VIN_BAT_1: SIP.Y3 (VIN_BAT_1)
V_DIV_BAT: SIP.A8 (AIN6); also elsewhere on the board
V_DIV_DC: SIP.B8 (AIN5); also elsewhere on the board
WLAN_IRQ: SIP.K16; also elsewhere on the board
WL_BT_OE: SIP.L18; also elsewhere on the board
WL_EN: SIP.K18; also elsewhere on the board

Notes on the sheet:
Pulled down on Pg 1
GPIO3_9
GPIO0_28
GPIO0_21
GPIO3_10

Notices in the files:
parts and their libraries:
SparkFun-Sensors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
