# Repository jadonk/beaglebone-blue (continued)

## EAGLE design BeagleBone Blue SIP Eagle/BeagleBone_Blue.brd (continued)

Parts:
C27, C28, C35, C37, C39, C40, C41: 0.1UF,6.3V; 0402-CAP
C29, C30, C31, C32: 18PF,50V; 0402-CAP
C33, C36: 2.2UF,6.3V; 0402-CAP
C34, C38: 10UF,10V; 0805
D8, D10, D11, D12, D13: BLUE; LED-0603
P10: SCHA5B0200
R2, R23, R58: 1.5K,1%; 0402-RES
R24: 4.75K,1%; 0402-RES
R59: 4.7K,1%; 0402-RES
R60, R65, R66, R67, R68, R69, R70, R71, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94: 10K,1%; 0402-RES
R61, R62, R63, R64: 261; 0402-RES
R72, R73, R76, R77, R78, R79, R82, R83, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104: 33; 0402-RES
R74, R75, R80, R81: 0; 0402-RES
SIP: OSD3358
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20: TPSQB1,27; B1,27
U5: 24LC_32AT-I/OT; SOT95P290X145-5N
U6: SN74LVC1G07_DCK_5; DCK5
U8: MTFC4GLDEA
Y1: CM200C-32.768KAZF-UT
Y2: 445C33D24M00000

Connections:
5.0V: SIP.Y5 (VIN_AC_0), SIP.Y6 (VIN_AC_1); also elsewhere on the board
GND: C27.2, C28.2, C33.2, C34.1, C35.1, C36.1, C37.2, C38.2, C39.2, C40.2, C41.2, P10.6 (VSS), P10.9 (GND), P10.11 (GND3), P10.12 (GND4), P10.13 (GND5), P10.14 (GND6), P10.15 (GND7), P10.16 (GND8), R24.2, R59.1, R61.1, R62.1, R63.1, R64.1, TP12.TP, U5.2 (VSS), U6.3 (GND), U8.C4 (VSSQ4), U8.E7 (VSS2), U8.G5 (VSS1), U8.H10 (VSS3), U8.K8 (VSS4), U8.N2 (VSSQ1), U8.N5 (VSS5), U8.P4 (VSSQ3), U8.P6 (VSSQ2); also elsewhere on the board
I2C0_SCL: R23.1, SIP.C16 (I2C0_SCL), SIP.C20 (PMIC_I2C_SCL), U5.1 (SCL)
I2C0_SDA: R2.1, SIP.C17 (I2C0_SDA), SIP.C19 (PMIC_I2C_SDA), U5.3 (SDA)
I2C1_SCL: R75.1; also elsewhere on the board
I2C1_SDA: R74.1; also elsewhere on the board
I2C2_SCL: R81.1; also elsewhere on the board
I2C2_SDA: R80.1; also elsewhere on the board
IMU_INT: SIP.A14 (GPIO3_21_A14); also elsewhere on the board
LDO_PGOOD: SIP.B5 (RTC_PWRONRSTN), SIP.B20 (PMIC_OUT_LDO_PGOOD)
LED_1: SIP.U12 (GPIO0_27_U12); also elsewhere on the board
LED_3: SIP.V6 (GPIO1_29_V6); also elsewhere on the board
LED_4: SIP.T11 (GPIO0_26_T11); also elsewhere on the board
LED_GRN: SIP.T7 (TIMER7_T7); also elsewhere on the board
LED_RED: SIP.R7 (TIMER4_R7); also elsewhere on the board
MDIR_1A: SIP.C12 (SPI1_CS0_C12); also elsewhere on the board
MDIR_1B: SIP.U17 (UART4_TXD_U17); also elsewhere on the board
MDIR_2A: SIP.R13 (GPIO1_16_R13); also elsewhere on the board
MODE_BTN: SIP.U6 (TIMER6_U6); also elsewhere on the board
MOT_STBY: SIP.D14 (GPIO0_20_D14); also elsewhere on the board
unnamed: SIP.Y2 (VIN_BAT_0), SIP.Y3 (VIN_BAT_1), TP2.TP
unnamed: SIP.Y1 (BAT_VOLT), TP3.TP
unnamed: SIP.W1 (BAT_TEMP), TP4.TP
unnamed: SIP.C6 (PMIC_POWER_EN), SIP.D19 (PMIC_IN_PWR_EN), TP5.TP
unnamed: SIP.Y14 (L1_IN), TP6.TP
unnamed: SIP.Y13 (L1_OUT), TP7.TP
unnamed: SIP.Y17 (L2_IN), TP8.TP
unnamed: SIP.Y16 (L2_OUT), TP9.TP
unnamed: SIP.Y20 (L3_IN), TP10.TP
unnamed: SIP.Y19 (L3_OUT), TP11.TP
unnamed: C30.1, SIP.M20 (OSC0_IN), Y1.2
unnamed: C29.1, SIP.K20 (OSC0_OUT), Y1.1
unnamed: R58.1, TP13.TP, U5.5 (WP)
unnamed: C29.2, C30.2, SIP.L20 (OSC0_GND)
unnamed: C31.1, SIP.H20 (OSC1_IN), Y2.2
unnamed: C32.2, SIP.F20 (OSC1_OUT), Y2.1
unnamed: C31.2, C32.1, SIP.G20 (OSC1_GND)
unnamed: SIP.B14 (JTAG_EMU1), TP14.TP
unnamed: SIP.C14 (JTAG_EMU0), TP15.TP
unnamed: SIP.A11 (JTAG_TDO), TP16.TP
unnamed: SIP.A12 (JTAG_TCK), TP17.TP
unnamed: SIP.B11 (JTAG_TDI), TP18.TP
unnamed: SIP.C11 (JTAG_TMS), TP19.TP
unnamed: R59.2, SIP.B10 (JTAG_TRSTN), TP20.TP
unnamed: D13.A, SIP.V16 (USR3_V16)
unnamed: D12.A, SIP.T15 (USR2_T15)
unnamed: D11.A, SIP.U15 (USR1_U15)
unnamed: D10.A, SIP.V15 (USR0_V15)
unnamed: D10.C, R61.2
unnamed: D11.C, R62.2
unnamed: D12.C, R63.2
unnamed: D13.C, R64.2
unnamed: P10.2 (CD/DAT3), R68.2, SIP.F17 (MMC0_DAT3_F17)
unnamed: R72.2, SIP.A17 (UART2_RXD_A17)
unnamed: P10.8 (DAT1), R66.2, SIP.G15 (MMC0_DAT1_G15)
unnamed: R73.2, SIP.B17 (UART2_TXD_B17)
unnamed: P10.5 (CLOCK), R70.2, SIP.G17 (MMC0_CLK_G17)
unnamed: P10.3 (CMD), R69.2, SIP.G18 (MMC0_CMD_G18)
unnamed: P10.10 (CD), R71.2, SIP.C15 (MMC0_CD_C15)
unnamed: R74.2, SIP.B16 (I2C1_SDA_B16)
unnamed: P10.7 (DAT0), R65.2, SIP.G16 (MMC0_DAT0_G16)
unnamed: R75.2, SIP.A16 (I2C1_SCL_A16)
unnamed: R76.2, SIP.E16 (UART0_TXD_E16)
unnamed: R77.2, SIP.E15 (UART0_RXD_E15)
unnamed: R78.2, SIP.D15 (UART1_TXD_D15)
unnamed: R79.2, SIP.D16 (UART1_RXD_D16)
unnamed: R80.2, SIP.D18 (I2C2_SDA_D18)
unnamed: R81.2, SIP.D17 (I2C2_SCL_D17)
unnamed: R82.1, SIP.A15 (GPIO0_19_A15)
unnamed: R83.1, SIP.T17 (UART4_RXD_T17)
unnamed: R84.1, SIP.T9 (MMC1_DAT7_T9), U8.B6 (DAT7)
unnamed: R85.1, SIP.R9 (MMC1_DAT6_R9), U8.B5 (DAT6)
unnamed: R86.1, SIP.V8 (MMC1_DAT5_V8), U8.B4 (DAT5)
unnamed: R87.1, SIP.U8 (MMC1_DAT4_U8), U8.B3 (DAT4)
unnamed: R88.1, SIP.T8 (MMC1_DAT3_T8), U8.B2 (DAT3)
unnamed: R89.1, SIP.R8 (MMC1_DAT2_R8), U8.A5 (DAT2)
unnamed: R90.1, SIP.V7 (MMC1_DAT1_V7), U8.A4 (DAT1)
unnamed: R91.1, SIP.U7 (MMC1_DAT0_U7), U8.A3 (DAT0)
unnamed: R92.1, SIP.V9 (MMC1_CMD_V9), U8.M5 (CMD)
unnamed: R93.1, SIP.U9 (MMC1_CLK_U9), U8.M6 (CLK)
unnamed: R94.1, SIP.R14 (EMMCRST_GPIO1_20_R14), U8.K5 (RST)
unnamed: R95.1, SIP.T12 (GPIO1_12_T12)
unnamed: R96.1, SIP.R12 (GPIO1_13_R12)
unnamed: R97.1, SIP.V13 (GPIO1_14_V13)
unnamed: R98.1, SIP.U13 (GPIO1_15_U13)
unnamed: R99.1, SIP.B12 (GPIO3_18_B12)
unnamed: R100.1, SIP.C13 (GPIO3_19_C13)
unnamed: R101.1, SIP.A13 (SPI1_CLK_A13)
unnamed: R102.1, SIP.B13 (SPI1_D0_B13)
unnamed: R103.1, SIP.D12 (SPI1_D1_D12)
unnamed: R104.1, SIP.E17 (UART0_RTSN_E17)
unnamed: C36.2, U8.C2 (VCCI)
NTE: P10.1 (DAT2), R67.2, SIP.F18 (MMC0_DAT2_F18)
PAUSE_BTN: SIP.T6 (TIMER5_T6); also elsewhere on the board
PMIC_INT: SIP.B18 (EXTINTN), SIP.B19 (PMIC_OUT_NINT)
PMIC_NWAKEUP: SIP.A19 (PMIC_OUT_NWAKEUP), SIP.C5 (EXT_WAKEUP)
PMIC_PGOOD: SIP.A20 (PMIC_OUT_PGOOD), SIP.B15 (PWRONRSTN), U6.2 (A)
PWM_1A: SIP.U14 (EHRPWM1A_U14); also elsewhere on the board
PWM_1B: SIP.T14 (EHRPWM1B_T14); also elsewhere on the board
PWM_2A: SIP.U10 (EHRPWM2A_U10); also elsewhere on the board
PWM_2B: SIP.T10 (EHRPWM2B_T10); also elsewhere on the board
PWR: SIP.D20 (PMIC_IN_PB_IN); also elsewhere on the board
PWR_LEDR: D8.C, R24.1
QEP_0A: R99.2; also elsewhere on the board
QEP_0B: R100.2; also elsewhere on the board
QEP_2A: R95.2; also elsewhere on the board
QEP_2B: R96.2; also elsewhere on the board
QEP_4A: R97.2; also elsewhere on the board
QEP_4B: R98.2; also elsewhere on the board
RESET: C33.1, R60.1, SIP.A10 (WARMRSTN), U6.4 (Y); also elsewhere on the board
SPI1_MISO: R102.2; also elsewhere on the board
SPI1_MOSI: R103.2; also elsewhere on the board
SPI1_SCK: R101.2; also elsewhere on the board
SPI1_SS1: R104.2; also elsewhere on the board
SPI1_SS2: R82.2; also elsewhere on the board
SYS_5V: SIP.W4 (VOUT_SYS_5V_0), SIP.Y4 (VOUT_SYS_5V_1), TP1.TP; also elsewhere on the board
UART0_RX: R77.1; also elsewhere on the board
UART0_TX: R76.1; also elsewhere on the board
UART1_RX: R79.1; also elsewhere on the board
UART1_TX: R78.1; also elsewhere on the board
UART2_RX: R72.1; also elsewhere on the board
UART2_TX: R73.1; also elsewhere on the board
UART4_RX: R83.2; also elsewhere on the board
USB_DC: SIP.Y8 (VIN_USB_0), SIP.Y9 (VIN_USB_1); also elsewhere on the board
VCC_3V3B: C34.2, C35.2, P10.4 (VDD), R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1
VDD_1V8: SIP.N16 (VOUT_LDO3_1P8V_0), SIP.R16 (VOUT_LDO3_1P8V_1); also elsewhere on the board
VDD_3V3A: C28.1, R2.2, R23.2, R58.2, R60.2, U5.4 (VCC); also elsewhere on the board
VDD_3V3AUX: D8.A, SIP.Y11 (VOUT_LDO2_3P3V)
VDD_3V3B: C27.1, C37.1, C38.1, C39.1, C40.1, C41.1, R84.2, R85.2, R86.2, R87.2, R88.2, R89.2, R90.2, R91.2, R92.2, R93.2, R94.2, SIP.U20 (VOUT_USER_3P3V_0), SIP.V20 (VOUT_USER_3P3V_1), U8.C6 (VCCQ4), U8.E6 (VCC3), U8.F5 (VCC2), U8.J10 (VCC0), U8.K9 (VCC1), U8.M4 (VCCQ5), U8.N4 (VCCQ3), U8.P3 (VCCQ1), U8.P5 (VCCQ2); also elsewhere on the board
VDD_RTC: U6.5 (VCC); also elsewhere on the board

Parts:
BOOT: SWITCH-MOMENTARY-2SMD-1101NE; TACTILE-SWITCH-1101NE
C42: 0.001UF,16V; 0402-CAP
C43, C44, C45: 0.1UF,6.3V; 0402-CAP
C46: 10UF,10V; 0805
C50: AVE107M06D16T-F
HOST: 87520-0010BLF
L4, L5: 120; L0603
R105, R106, R107, R108, R111, R146, R147, R149, R150, R152, R154: 0; 0402-RES
R109, R110: 4.75K,1%; 0402-RES
R113, R115, R116, R118, R120, R122, R125, R127, R129, R131, R133, R135, R137, R139, R140, R143: 100K,1%; 0402-RES
R144, R145, R156: 33; 0402-RES
R148: 100; 0402-RES
R151: 10K,1%; 0402-RES
R153, R155: 0,DNI; 0402-RES
R157: 10K,1%,DNI; 0402-RES
SIP: OSD3358
U1, U4: TPD4S012_DRY_6; DRY6
U7: TPS2051B_D_8; D8
USB: USB-AB; USB-AB-MICRO-SMD

Connections:
5.0V: R152.1; also elsewhere on the board
AIN0: R105.1; also elsewhere on the board
AIN1: R106.1; also elsewhere on the board
AIN2: R107.1; also elsewhere on the board
AIN3: R108.1; also elsewhere on the board
GND: BOOT.2, C45.2, C46.2, C50.- (2), HOST.S1 (SH0), HOST.S2 (SH1), L4.1, R110.2, R113.1, R115.1, R125.1, R127.1, R129.1, R131.1, R133.1, R135.1, R137.1, R139.1, R143.1, R150.2, R151.1, U1.4 (GND), U4.4 (GND), U7.1 (GND), USB.GND, USB.SHIELD1 (SHIELD), USB.SHIELD2 (SHIELD), USB.SHIELD3 (SHIELD), USB.SHIELD4 (SHIELD); also elsewhere on the board
GNDA_ADC: C42.2, C43.2, C44.2, SIP.A6 (VSSA_ADC_0), SIP.A9 (VSSA_ADC_1), SIP.E8 (VSSA_ADC_2)
LED_2: R143.2, SIP.T5 (LCD_DATA15_T5); also elsewhere on the board
MDIR_2B: R140.1, SIP.V4 (LCD_DATA14_V4); also elsewhere on the board
MDIR_3A: R118.1, SIP.R4 (LCD_DATA3_R4); also elsewhere on the board
MDIR_3B: R116.1, R148.1, SIP.R3 (LCD_DATA2_R3); also elsewhere on the board
MDIR_4A: R113.2, SIP.R1 (LCD_DATA0_R1); also elsewhere on the board
MDIR_4B: R115.2, SIP.R2 (LCD_DATA1_R2); also elsewhere on the board
unnamed: R155.1, SIP.T16 (USB1OC_GPIO1_26_T16)
unnamed: C42.1, C43.1, R111.2, SIP.B9 (ADC_VREFP)
unnamed: R105.2, SIP.B6 (AIN0)
unnamed: R106.2, SIP.C7 (AIN1)
unnamed: R107.2, SIP.B7 (AIN2)
unnamed: R108.2, SIP.A7 (AIN3)
unnamed: R109.2, R110.1, SIP.C9 (AIN7)
unnamed: BOOT.1, R148.2
unnamed: SIP.N17 (USB0_DP), U1.1 (D+), USB.D+
unnamed: SIP.N18 (USB0_DM), U1.2 (D-), USB.D-
unnamed: SIP.P16 (USB0_ID), U1.3 (ID), USB.ID (USBID)
unnamed: R151.2, SIP.F15 (USB1_DRVVBUS), U7.4 (*EN)
unnamed: R149.1, SIP.P15 (USB0_VBUS)
unnamed: C45.1, C46.1, L5.1, R156.2, U4.6 (VBUS), U7.6 (OUT_2), U7.7 (OUT_3), U7.8 (OUT)
unnamed: HOST.3 (D+), SIP.R17 (USB1_DP), U4.1 (D+)
unnamed: HOST.2 (D-), SIP.R18 (USB1_DM), U4.2 (D-)
unnamed: R155.2, R157.2, U7.5 (*OC)
unnamed: R150.1, SIP.P17 (USB1_ID)
unnamed: C50.+ (1), R152.2, R153.2, U7.2 (IN_2), U7.3 (IN)
unnamed: HOST.4 (GND), L4.2
unnamed: R156.1, SIP.T18 (USB1_VBUS)
unnamed: HOST.1 (VBUS), L5.2
unnamed: R129.2, R144.1, SIP.U1 (LCD_DATA8_U1)
unnamed: R131.2, R145.1, SIP.U2 (LCD_DATA9_U2)
unnamed: R135.2, SIP.U4 (LCD_DATA11_U4)
unnamed: R137.2, R146.1, SIP.V2 (LCD_DATA12_V2)
unnamed: R139.2, R147.1, SIP.V3 (LCD_DATA13_V3)
QEP_1A: R146.2; also elsewhere on the board
QEP_1B: R147.2; also elsewhere on the board
SERVO_EN: R133.2, SIP.U3 (LCD_DATA10_U3); also elsewhere on the board
SVO1: SIP.U5 (LCD_VSYNC_U5); also elsewhere on the board
SVO2: SIP.V5 (LCD_PCLK_V5); also elsewhere on the board
SVO3: SIP.R5 (LCD_HSYNC_R5); also elsewhere on the board
SVO4: SIP.R6 (LCD_DE_R6); also elsewhere on the board
SVO5: R125.2, SIP.T3 (LCD_DATA6_T3); also elsewhere on the board
SVO6: R127.2, SIP.T4 (LCD_DATA7_T4); also elsewhere on the board
SVO7: R120.1, SIP.T1 (LCD_DATA4_T1); also elsewhere on the board
SVO8: R122.1, SIP.T2 (LCD_DATA5_T2); also elsewhere on the board
SYS_5V: R153.1; also elsewhere on the board
UART5_RX: R145.2; also elsewhere on the board
UART5_TX: R144.2; also elsewhere on the board
USB0_VBUS: R149.2, R154.1, U1.6 (VBUS), USB.VBUS
USB_DC: R154.2; also elsewhere on the board
VDD_3V3A: R116.2, R118.2, R120.2, R122.2, R140.2, R157.1; also elsewhere on the board
VDD_3V3B: R109.1; also elsewhere on the board
VDD_ADC: C44.1, R111.1, SIP.A4 (VOUT_ADC_1P8V_0), SIP.A5 (VOUT_ADC_1P8V_1); also elsewhere on the board
V_DIV_BAT: SIP.A8 (AIN6); also elsewhere on the board
V_DIV_DC: SIP.B8 (AIN5); also elsewhere on the board

Parts:
R158: 10K,1%; 0402-RES
SIP: OSD3358

Connections:
GND: R158.2, SIP.A1 (DGND1), SIP.A18 (DGND2), SIP.E19 (DGND3), SIP.E20 (DGND4), SIP.F8 (DGND5), SIP.F19 (DGND6), SIP.G8 (DGND7), SIP.G9 (DGND8), SIP.G11 (DGND9), SIP.G12 (DGND10), SIP.G19 (DGND11), SIP.H6 (DGND12), SIP.H7 (DGND13), SIP.H8 (DGND14), SIP.H9 (DGND15), SIP.H10 (DGND16), SIP.H12 (DGND17), SIP.H19 (DGND18), SIP.J6 (DGND19), SIP.J7 (DGND20), SIP.J8 (DGND21), SIP.J9 (DGND22), SIP.J10 (DGND23), SIP.J11 (DGND24), SIP.J19 (DGND25), SIP.J20 (DGND26), SIP.K7 (DGND27), SIP.K9 (DGND28), SIP.K10 (DGND29), SIP.K11 (DGND30), SIP.K19 (DGND31), SIP.L10 (DGND32), SIP.L11 (DGND33), SIP.L12 (DGND34), SIP.L13 (DGND35), SIP.L19 (DGND36), SIP.M6 (DGND38), SIP.M7 (DGND39), SIP.M8 (DGND40), SIP.M9 (DGND41), SIP.M10 (DGND42), SIP.M12 (DGND43), SIP.M14 (DGND44), SIP.M19 (DGND45), SIP.N7 (DGND46), SIP.N10 (DGND47), SIP.N11 (DGND48), SIP.N14 (DGND49), SIP.N19 (DGND50), SIP.N20 (DGND51), SIP.P19 (DGND52), SIP.P20 (DGND53), SIP.R19 (DGND54), SIP.R20 (DGND55), SIP.T19 (DGND56), SIP.T20 (DGND57), SIP.U19 (DGND58), SIP.V1 (DGND59), SIP.V18 (DGND60), SIP.V19 (DGND61), SIP.W2 (DGND62), SIP.W3 (DGND63), SIP.W5 (DGND65), SIP.W6 (DGND66), SIP.W7 (DGND67), SIP.W8 (DGND68), SIP.W9 (DGND69), SIP.W10 (DGND70), SIP.W11 (DGND71), SIP.W12 (DGND72), SIP.W13 (DGND73), SIP.W14 (DGND74), SIP.W15 (DGND75), SIP.W16 (DGND76), SIP.W17 (DGND77), SIP.W18 (DGND78), SIP.W19 (DGND79), SIP.W20 (DGND80), SIP.Y7 (DGND82)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; also elsewhere on the board
unnamed: R158.1, SIP.B4 (RTC_KALDO_ENN)
VDD_1V8: SIP.D10 (VDD_1V84), SIP.E9 (VDD_1V83); also elsewhere on the board
VDD_3V3A: SIP.E10 (VDD_3V3A1), SIP.E11 (VDD_3V3A2), SIP.E12 (VDD_3V3A3), SIP.E13 (VDD_3V3A4), SIP.F14 (VDD_3V3A5), SIP.G14 (VDD_3V3A6), SIP.H14 (VDD_3V3A7), SIP.J14 (VDD_3V3A8), SIP.K14 (VDD_3V3A9), SIP.L14 (VDD_3V3A10), SIP.N5 (VDD_3V3A11), SIP.N15 (VDD_3V3A12), SIP.P5 (VDD_3V3A13), SIP.P6 (VDD_3V3A14), SIP.P7 (VDD_3V3A15), SIP.P8 (VDD_3V3A16), SIP.P10 (VDD_3V3A17), SIP.P11 (VDD_3V3A18), SIP.P12 (VDD_3V3A19), SIP.P13 (VDD_3V3A20), SIP.R15 (VDD_3V3A21); also elsewhere on the board
VDD_ADC: SIP.D8 (VDDA_ADC); also elsewhere on the board
VDD_RTC: SIP.D7 (VDD_RTC1), SIP.E6 (VDD_RTC2), SIP.E14 (VDD_RTC3), SIP.F9 (VDD_RTC4), SIP.K13 (VDD_RTC5), SIP.N6 (VDD_RTC6), SIP.P9 (VDD_RTC7), SIP.P14 (VDD_RTC8); also elsewhere on the board

Board: 2 copper layers, 281 parts (47 on the bottom side), 241 nets, no tracks yet.

Other parts of the board:
BOARD: BEAGLEBONE_BLUE_NO_HOLES
E$1: BATTERY_INDICATOR
U$5: XYZ_BIG

## Commit log (part)

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2015-12-18 Adjust QEP index
2015-12-18 Rough place some parts
2015-12-18 Switch QEP pull-ups to pull-downs
2015-12-18 Remove extraneous pull-downs
2015-12-20 Rough place UART0 resistors
2015-12-20 Rough place UART0 resistors to avoid uSD cage
2015-12-20 Extended USB connectors slightly over edge
2015-12-20 ERC: fix USB ground junction
2015-12-20 ERC: add USB value
2015-12-20 DRC fixes
2015-12-21 Shuffle some parts to make more room for traces
2015-12-21 Remove a bunch of redudnant grounds
2015-12-21 Shuffle some parts and pre-route USB host
2015-12-21 Update USB route
2015-12-21 Add 2 layers
2015-12-21 Rename GND layer
2015-12-21 Try moving LEDs and buttons
2015-12-21 Shuffle a few parts to reduce congestion
2015-12-22 Fix VCC
    CHGIC VIN was connected to "5.0V", not VCC.
2015-12-22 Remove unpredictable ports
    Used labels and net names rather than power ports
2015-12-22 Major shuffle to reduce conjestion
2015-12-23 Partial major layout change to improve routing
2015-12-23 Re-enable display of all layers
2015-12-23 Restore OSHPark 2-layer design rules
2015-12-23 eMMC pull-ups
    CMD/CLK are pulled up internally by AM335x on reset.
    DATx are pulled down internally by AM335x on reset and are push-pull in
    operation.
2015-12-23 In the middle of rearranging the connectors to simplify layout
2015-12-23 Remove redundant pull-down resistor R133
2015-12-23 Small relocations
2015-12-23 Connect VDD_3V3B to 3.3V
2015-12-23 Correctly connect VDD_3V3B to 3.3V
2015-12-23 Move U5 from VDD_3V3A to 3.3V
2015-12-23 Move U6 from VDD_3V3A to 3.3V
2015-12-23 Move pull-ups from VDD_3V3A to 3.3V
2015-12-23 Remove unused VDD_3V3A
2015-12-23 Look at moving eMMC and test points
2015-12-23 Quick place on robotics connectors
2015-12-24 Unsuccessful hacks to try to simplify routing
2015-12-24 Use internal pull-ups for QEP to be applied after boot
2015-12-24 Fix some DRCs
2015-12-24 Crazy position moves trying anything to make it more routable
2015-12-24 Try moving LEDs due to the long traces
2015-12-27 Move parts to try to improve routing
2015-12-27 Move parts back
2015-12-28 Remove eMMC for now since will not route at 5 mil
2015-12-28 Remove BOOT button
2015-12-28 Remove USB protection circuits
2015-12-28 Remove separate USB voltage regulator
2015-12-28 Remove eMMC decoupling caps
2015-12-29 Swap out uSD connector to one at Sparkfun
2015-12-29 Remove pull-ups redundant with on-chip pull-ups
2015-12-29 Hack 100% autorouted with side connectors on one side
2015-12-29 Undo route
2015-12-29 Space connectors and buttons out a bit
2015-12-29 Move buttons
2015-12-29 Small shifts
2015-12-29 Move USB client power resistors
2015-12-29 Move crystal
2015-12-29 Small shifts for DRC
2015-12-29 Switch to 2-layer OSHPark DRC
2015-12-29 Switch to Sunstone DRU
2015-12-29 DRC fix
2015-12-30 Move uSD to top to try to improve routing
2015-12-30 Move uSD back and fix DRCs
2015-12-30 Struggling with 6 mil rules
2016-01-13 Unknown
2016-01-13 First attempt at a BOM
2016-01-13 Had added wrong file
2016-01-13 Move to an XML format for the BOM
2016-01-13 Consolidate some BOM line items
2016-01-15 Touched BOM
2016-01-23 Add gerbers for A0 hack
2016-01-24 Threw in resistor and capacitor values GHI had handy
2016-01-26 put strawson_eagle_lib.lbr back in for BMP280 device
2016-01-26 swap BMP180 for BMP280 in schematic
2016-01-26 Open SEL pin on charger to change voltage to 4.2V
2016-01-26 Place BMP
2016-01-26 Ripup entire route
2016-01-27 Save with Jason's EAGLE
2016-01-27 remove servo5-8 pulldowns
2016-01-28 change MDIR_2B to pin u4
2016-02-03 Update BeagleBone_Blue.xml BOM
2016-02-28 Add new sheet
2016-03-06 Add start of WiFi/BT
2016-03-06 Move to an XML pin table to track changes
2016-03-07 Update pins
2016-03-07 Update some of the WiFi/BT connection
2016-03-07 Add pinmux file
2016-03-07 Minor
2016-03-07 Oops
2016-05-11 Remove extra junk
2016-05-11 Update Wilink8 connections
2016-06-29 Revert "Remove eMMC for now since will not route at 5 mil"
    This reverts commit 75f1e67d3ee9893e94103e41b84841ae77a6b699.
    Conflicts:
    EAGLE_SIP/BeagleBone_Blue.brd
    EAGLE_SIP/BeagleBone_Blue.sch
2016-06-29 Move parts just to show they fit
2016-06-29 SPI1_SS2: net connect
2016-06-29 Add resistor to MMC1_CLK
2016-07-18 Connected GND for SiP
2016-07-18 Added resistors to clock circuits.
2016-07-19 Added grove connectors; SD boot pushbutton
2016-07-19 Fixed I2C EEPROM wiring.
2016-07-19 Wired MMC0 pull ups. Moved components on page 1.
2016-07-19 Added MMC1 pullups; re-arranged some components.
2016-07-19 Updated SiP pinout.
2016-07-19 Sync schematics / board.
2016-07-19 Cleaned up some resistor values
2016-07-19 Added WL1835 from BBBW.
2016-07-19 Added CAN transceiver.
2016-07-20 Added USB ESD protection.
2016-07-20 Playing with placement.
2016-07-20 Updated BOM, footprints.
2016-07-20 Updated crystal cap values to match BBBW.
2016-07-22 placement update
2016-07-24 XML file opened
2016-07-25 Updating board.
2016-07-25 Removed SVO5 - SVO8 pulldown resistors. Conflict w/ bootmode PU/PDs.
2016-07-25 Board update.
2016-07-25 Board update
2016-07-26 Placement review.
2016-07-26 Updated clock footprints. Fixed error w/ AM335x clocks.
2016-07-26 BeagleBone_Blue.xml: nothing significant
2016-07-26 Align sch/brd crytal caps
2016-07-26 Change IMU footprint and orientation
2016-07-27 Fixed V_BATT for 6V reg.
2016-07-27 New power layout.
2016-07-27 Board updates.
2016-07-27 Power mostly complete.
2016-07-28 Updated placement.
2016-07-28 placement update.
2016-07-28 Re-ordered level shifters.
2016-07-29 Updated parts: micro SD, micro USB, USB to match BBBW.
2016-07-29 Added ESD ring; Fixed mouting holes.
2016-07-31 Updated EMMC componen to match BBBW. Footprint of other component was not routable in 6 mil traces.
2016-08-01 board updates
2016-08-02 replaced some test points with smaller test points.
2016-08-05 LICENSE: updated to CC-BY-4.0
2016-08-10 Updated silk screen.
2016-08-11 touchups. Ready for review.
2016-08-11 Change Rev to A1
2016-08-11 Fixed power connector footprint. Changed to Rev A1.
2016-08-11 Matched length of USB lines.
2016-08-11 Fix missing junction
2016-08-11 Fixing Eagle warnings. Warnings were not an issue but cleaning up anyway.
2016-08-15 BeagleBone_Blue_brd.pdf: added PCB preview
2016-08-15 Content/directory clean-up
2016-08-15 BealeBone_Blue_sch.pdf: updated for Rev A1
2016-08-18 Remove old/inaccurate BOM files
2016-08-18 Move pinmux file
2016-08-18 BOM: created
2016-08-18 Update BOM with some MPNs
2016-08-19 BOM: remove unimportant columns
2016-08-19 BOM: combine MFR and MPN
2016-08-25 BOM: Add antenna
2016-08-30 BOM: clarify some part numbers
2016-08-30 BOM: spec some Rs and Cs
2016-08-30 BOM: add N/A for DNP part manufacturer
2016-08-30 BRD: cleaned up some silkscreen
2016-08-30 BRD: move R107 for selective solder
    R107 connects GND to CGND. To solder the power connector (a through-hole component), we'll need to utilize a selective solder machine. That machine needs more clearance not running over surface mount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
2016-08-30 Moving R107 and R24 to be farther away from wave soldering parts.
2016-08-30 EAGLE: attempt to consolidate library
    I probably have no idea what I'm doing. I'm also concerned I might have messed up D1.
2016-08-30 EAGLE: more attempts to consolidate library
    I tried to rename some parts to eliminate the prefixes added by the exp-lbrs.ulp script.
2016-08-30 BRD: update D1, D2, D3 footprints
2016-08-30 Remove Strawson_Eagle_Lib.lbr
2016-08-30 Updated routing for D1, D2 and D3.
2016-08-30 Updated layout around USB connector to allow for more space for wave solder.
2016-09-07 Fixing silkscreen issues.
2016-09-20 Update pinmux to reflect A1
2016-09-20 Fix WL_IRQ GPIO note
2016-10-05 Add terms to README.md
2016-10-12 Moved R24 and R107 for manufacturing concerns. Cleaned up some power pours on the top and bottom.
2016-10-12 Moved L3 for manufacturing issues.
2016-10-13 Schematic updates for Rev A2. See Issues.
2016-10-13 Fixing PDF.
2016-10-14 Added TPS2105 power mux for USB1 power.
2016-10-18 Intermediate commit; Updated layout; Fixed TPS2105 footprint.
2016-10-18 Updated placement
2016-10-18 Updated schematics: removed some test points; changed GPIO 1 connector to 6 pin JST; Updated EQEP layout.
2016-10-18 Updated L1, Q1 for DFM issues from manufacturer.
2016-10-19 Cleaned up top side silkscreen
2016-10-19 Updates to silkscreen.
2016-10-19 Updated layout.
2016-10-20 Fixed L4, L5 DFM issues; Updated layout.
2016-10-21 Updated button placement (preliminary).
2016-10-22 A2 routing finished.
2016-10-23 Updated C21 value; Cleaned up silk screen.
2016-10-23 Updated silkscreen.
2016-10-26 Updates for DFM issues.
2016-10-27 Updated PDF and BOM based on latest schematics.
2016-10-27 Revert "Updated PDF and BOM based on latest schematics."
    This reverts commit 34783d9e17dd36a21b3d147bf87b06cee4abf9bb.
    Erik's commit inadvertently removed all of the carriage returns at the end of hte .CSV file.
2016-10-27 Reapply schematic PDF update
2016-10-27 Update BOM for current schematic
2016-11-01 BOM: Updates from Embest
2016-11-01 BOM: Add question marks
2016-11-01 Add gerber files
2016-11-02 Gerber update
    * Rename files to match OSH Park "standard"
    * Fix outline by including layer 20
    * Update README.md to describe files
    * Update cam file to reproduce the output
    * Update drill file format precision (was causing OSH Park issues)
2016-11-03 Update UCSD link
2016-11-04 Update brd.pdf to A2
2016-11-05 update pin table with new mdir2b and gpio headers
2016-11-06 pull new DCAN and SPI_SS pins from schematic to table
2016-11-22 Add graphic for conformal coat specification
2016-11-22 Adjusted cam file based on OSH Park feedback
    http://support.oshpark.com/support/tickets/29961#
2016-11-22 Update with silkscreen from Embest
2016-12-08 Add Gitter badge
2017-01-13 Update README.md
    Move gitter badge
2017-01-16 BeagleBone_Blue.pinmux: updated for rev A2
2017-01-16 BeagleBone_Blue.pinmux: fix some pin directions
2017-01-16 BOM: add alternates
2017-01-30 Revert "pull new DCAN and SPI_SS pins from schematic to table"
    This reverts commit 4e067f5e1d7aef13628bb9526eb36e3b84eef1b9.
2017-01-30 Revert "update pin table with new mdir2b and gpio headers"
    This reverts commit f9327dfb45372d406d32ded716de87cc40be3364.
2017-01-30 Pin table converted from XML to CSV
2017-01-30 Pin table: remove extra columns
2017-01-30 Pin table: revisit headings
2017-01-30 Pin table: swap first 2 columns
2017-01-30 Pin table: replace purple with N/C
2017-02-02 docs/BeagleBone_Blue_balloons.pdf: created
2017-02-02 Add callout picture of the board
2017-02-08 Update BeagleBone_Blue_BOM.csv
    Fix TB6612FNG name
2017-02-08 Update balloons drawings
2017-02-13 Update balloon graphics background (no fill)
2017-02-13 docs/balloons: Fix table borders
2017-02-17 Add BeagleBone_Blue_ShortSpec.pdf
2017-02-17 ShortSpec: highlight different software packages
2017-02-20 Updated with changes from Christi
2017-02-20 Update wording a bit
2017-02-20 Add recommended accessories
2017-02-20 Highlight links
2017-02-28 Update BeagleBone_Blue_BOM.csv
    Tighten up the tolerance on the voltage reading resistors
2017-03-02 Change gitter.im badge from jadonk to beagleboard
2017-03-03 Fix spelling mistake
    occsaions -> occasions
2017-03-04 Update PDF schematic to make it searchable
2017-03-04 Update PDF schematic to make it searchable (fix_
2017-03-04 Update PDF schematic to make it searchable (again)
2017-03-04 Saved schematic in EAGLE 8
2017-03-11 Add FCC/CE report
2017-03-15 Add OSHWA logo
2017-04-13 added some documentation
2017-09-20 Add motor driver strength
    https://github.com/beagleboard/beaglebone-blue/issues/9
2017-10-20 Issue #8 Motor driver chip is mislabelled pdf
    Updated the PDF with the typo fixed
2017-10-20 Issue #8 Motor driver chip is mislabelled EAGLE
    A global search and replace s/TB6621FNG/TB6612FNG/g of
    the eagle files.
2017-11-02 List temperature range of parts in BOM
